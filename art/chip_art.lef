VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO chip_art
  CLASS BLOCK ;
  FOREIGN chip_art ;
  ORIGIN 0.000 0.000 ;
  SIZE 26.880 BY 26.880 ;
  OBS
      LAYER met1 ;
        RECT 0.000 25.760 26.880 26.880 ;
        RECT 0.000 24.920 6.160 25.760 ;
      LAYER met1 ;
        RECT 6.160 24.920 7.000 25.760 ;
      LAYER met1 ;
        RECT 7.000 24.920 8.400 25.760 ;
      LAYER met1 ;
        RECT 8.400 24.920 9.240 25.760 ;
      LAYER met1 ;
        RECT 9.240 24.920 10.640 25.760 ;
      LAYER met1 ;
        RECT 10.640 24.920 11.480 25.760 ;
      LAYER met1 ;
        RECT 11.480 24.920 12.880 25.760 ;
      LAYER met1 ;
        RECT 12.880 24.920 13.720 25.760 ;
      LAYER met1 ;
        RECT 13.720 24.920 15.120 25.760 ;
      LAYER met1 ;
        RECT 15.120 24.920 15.960 25.760 ;
      LAYER met1 ;
        RECT 15.960 24.920 17.360 25.760 ;
      LAYER met1 ;
        RECT 17.360 24.920 18.200 25.760 ;
      LAYER met1 ;
        RECT 18.200 24.920 19.600 25.760 ;
      LAYER met1 ;
        RECT 19.600 24.920 20.440 25.760 ;
      LAYER met1 ;
        RECT 20.440 24.920 26.880 25.760 ;
        RECT 0.000 24.640 6.440 24.920 ;
      LAYER met1 ;
        RECT 6.440 24.640 7.000 24.920 ;
      LAYER met1 ;
        RECT 7.000 24.640 8.680 24.920 ;
      LAYER met1 ;
        RECT 8.680 24.640 9.240 24.920 ;
      LAYER met1 ;
        RECT 9.240 24.640 10.920 24.920 ;
      LAYER met1 ;
        RECT 10.920 24.640 11.200 24.920 ;
      LAYER met1 ;
        RECT 11.200 24.640 13.160 24.920 ;
        RECT 0.000 24.360 6.720 24.640 ;
      LAYER met1 ;
        RECT 6.720 24.360 7.280 24.640 ;
      LAYER met1 ;
        RECT 7.280 24.360 8.960 24.640 ;
      LAYER met1 ;
        RECT 8.960 24.360 9.520 24.640 ;
      LAYER met1 ;
        RECT 9.520 24.360 10.920 24.640 ;
      LAYER met1 ;
        RECT 10.920 24.360 11.480 24.640 ;
      LAYER met1 ;
        RECT 11.480 24.360 13.160 24.640 ;
        RECT 0.000 24.080 7.000 24.360 ;
      LAYER met1 ;
        RECT 7.000 24.080 7.560 24.360 ;
      LAYER met1 ;
        RECT 7.560 24.080 9.240 24.360 ;
      LAYER met1 ;
        RECT 9.240 24.080 9.800 24.360 ;
      LAYER met1 ;
        RECT 9.800 24.080 11.200 24.360 ;
      LAYER met1 ;
        RECT 11.200 24.080 11.760 24.360 ;
      LAYER met1 ;
        RECT 11.760 24.080 13.160 24.360 ;
        RECT 0.000 23.800 7.280 24.080 ;
      LAYER met1 ;
        RECT 7.280 23.800 7.840 24.080 ;
      LAYER met1 ;
        RECT 7.840 23.800 9.520 24.080 ;
      LAYER met1 ;
        RECT 9.520 23.800 10.360 24.080 ;
      LAYER met1 ;
        RECT 10.360 23.800 11.480 24.080 ;
      LAYER met1 ;
        RECT 11.480 23.800 12.040 24.080 ;
      LAYER met1 ;
        RECT 0.000 23.520 7.560 23.800 ;
      LAYER met1 ;
        RECT 7.560 23.520 8.120 23.800 ;
      LAYER met1 ;
        RECT 8.120 23.520 10.080 23.800 ;
      LAYER met1 ;
        RECT 10.080 23.520 10.640 23.800 ;
      LAYER met1 ;
        RECT 0.000 23.240 7.840 23.520 ;
      LAYER met1 ;
        RECT 7.840 23.240 8.400 23.520 ;
      LAYER met1 ;
        RECT 8.400 23.240 10.360 23.520 ;
        RECT 0.000 22.960 8.120 23.240 ;
      LAYER met1 ;
        RECT 8.120 22.960 8.680 23.240 ;
      LAYER met1 ;
        RECT 8.680 22.960 10.360 23.240 ;
        RECT 0.000 22.680 8.400 22.960 ;
      LAYER met1 ;
        RECT 8.400 22.680 8.960 22.960 ;
      LAYER met1 ;
        RECT 8.960 22.680 10.360 22.960 ;
        RECT 0.000 22.400 8.680 22.680 ;
      LAYER met1 ;
        RECT 8.680 22.400 9.240 22.680 ;
      LAYER met1 ;
        RECT 0.000 21.560 8.960 22.400 ;
      LAYER met1 ;
        RECT 8.960 21.560 9.240 22.400 ;
      LAYER met1 ;
        RECT 9.240 21.560 10.360 22.680 ;
      LAYER met1 ;
        RECT 10.360 21.560 10.640 23.520 ;
      LAYER met1 ;
        RECT 10.640 21.560 11.760 23.800 ;
      LAYER met1 ;
        RECT 11.760 21.560 12.040 23.800 ;
      LAYER met1 ;
        RECT 12.040 21.560 13.160 24.080 ;
      LAYER met1 ;
        RECT 13.160 21.560 13.440 24.920 ;
      LAYER met1 ;
        RECT 13.440 24.640 15.400 24.920 ;
      LAYER met1 ;
        RECT 15.400 24.640 15.680 24.920 ;
      LAYER met1 ;
        RECT 15.680 24.640 17.360 24.920 ;
      LAYER met1 ;
        RECT 17.360 24.640 17.920 24.920 ;
      LAYER met1 ;
        RECT 17.920 24.640 19.600 24.920 ;
      LAYER met1 ;
        RECT 19.600 24.640 20.160 24.920 ;
      LAYER met1 ;
        RECT 20.160 24.640 26.880 24.920 ;
        RECT 13.440 24.360 15.120 24.640 ;
      LAYER met1 ;
        RECT 15.120 24.360 15.680 24.640 ;
      LAYER met1 ;
        RECT 15.680 24.360 17.080 24.640 ;
      LAYER met1 ;
        RECT 17.080 24.360 17.640 24.640 ;
      LAYER met1 ;
        RECT 17.640 24.360 19.320 24.640 ;
      LAYER met1 ;
        RECT 19.320 24.360 19.880 24.640 ;
      LAYER met1 ;
        RECT 19.880 24.360 26.880 24.640 ;
        RECT 13.440 24.080 14.840 24.360 ;
      LAYER met1 ;
        RECT 14.840 24.080 15.400 24.360 ;
      LAYER met1 ;
        RECT 15.400 24.080 16.800 24.360 ;
      LAYER met1 ;
        RECT 16.800 24.080 17.360 24.360 ;
      LAYER met1 ;
        RECT 17.360 24.080 19.040 24.360 ;
      LAYER met1 ;
        RECT 19.040 24.080 19.600 24.360 ;
      LAYER met1 ;
        RECT 19.600 24.080 26.880 24.360 ;
        RECT 13.440 21.560 14.560 24.080 ;
      LAYER met1 ;
        RECT 14.560 23.800 15.120 24.080 ;
      LAYER met1 ;
        RECT 15.120 23.800 16.240 24.080 ;
      LAYER met1 ;
        RECT 16.240 23.800 17.080 24.080 ;
      LAYER met1 ;
        RECT 17.080 23.800 18.760 24.080 ;
      LAYER met1 ;
        RECT 18.760 23.800 19.320 24.080 ;
      LAYER met1 ;
        RECT 19.320 23.800 26.880 24.080 ;
      LAYER met1 ;
        RECT 14.560 21.560 14.840 23.800 ;
      LAYER met1 ;
        RECT 14.840 21.560 15.960 23.800 ;
      LAYER met1 ;
        RECT 15.960 23.520 16.520 23.800 ;
      LAYER met1 ;
        RECT 16.520 23.520 18.480 23.800 ;
      LAYER met1 ;
        RECT 18.480 23.520 19.040 23.800 ;
      LAYER met1 ;
        RECT 19.040 23.520 26.880 23.800 ;
      LAYER met1 ;
        RECT 15.960 21.560 16.240 23.520 ;
      LAYER met1 ;
        RECT 16.240 23.240 18.200 23.520 ;
      LAYER met1 ;
        RECT 18.200 23.240 18.760 23.520 ;
      LAYER met1 ;
        RECT 18.760 23.240 26.880 23.520 ;
        RECT 16.240 22.960 17.920 23.240 ;
      LAYER met1 ;
        RECT 17.920 22.960 18.480 23.240 ;
      LAYER met1 ;
        RECT 18.480 22.960 26.880 23.240 ;
        RECT 16.240 22.680 17.640 22.960 ;
      LAYER met1 ;
        RECT 17.640 22.680 18.200 22.960 ;
      LAYER met1 ;
        RECT 18.200 22.680 26.880 22.960 ;
        RECT 16.240 21.560 17.360 22.680 ;
      LAYER met1 ;
        RECT 17.360 22.400 17.920 22.680 ;
      LAYER met1 ;
        RECT 17.920 22.400 26.880 22.680 ;
      LAYER met1 ;
        RECT 17.360 21.560 17.640 22.400 ;
      LAYER met1 ;
        RECT 17.640 21.560 26.880 22.400 ;
        RECT 0.000 20.720 8.680 21.560 ;
        RECT 0.000 19.880 0.840 20.720 ;
      LAYER met1 ;
        RECT 0.840 20.440 1.680 20.720 ;
      LAYER met1 ;
        RECT 1.680 20.440 8.680 20.720 ;
      LAYER met1 ;
        RECT 0.840 19.880 1.960 20.440 ;
      LAYER met1 ;
        RECT 1.960 20.160 8.680 20.440 ;
      LAYER met1 ;
        RECT 8.680 20.160 9.520 21.560 ;
      LAYER met1 ;
        RECT 9.520 20.160 10.080 21.560 ;
      LAYER met1 ;
        RECT 10.080 20.160 10.920 21.560 ;
      LAYER met1 ;
        RECT 10.920 20.160 11.480 21.560 ;
      LAYER met1 ;
        RECT 11.480 20.160 12.320 21.560 ;
      LAYER met1 ;
        RECT 12.320 20.160 12.880 21.560 ;
      LAYER met1 ;
        RECT 12.880 20.160 13.720 21.560 ;
      LAYER met1 ;
        RECT 13.720 20.160 14.280 21.560 ;
      LAYER met1 ;
        RECT 14.280 20.160 15.120 21.560 ;
      LAYER met1 ;
        RECT 15.120 20.160 15.680 21.560 ;
      LAYER met1 ;
        RECT 15.680 20.160 16.520 21.560 ;
      LAYER met1 ;
        RECT 16.520 20.160 17.080 21.560 ;
      LAYER met1 ;
        RECT 17.080 20.160 17.920 21.560 ;
      LAYER met1 ;
        RECT 17.920 20.720 26.880 21.560 ;
        RECT 17.920 20.440 25.200 20.720 ;
      LAYER met1 ;
        RECT 25.200 20.440 26.040 20.720 ;
      LAYER met1 ;
        RECT 17.920 20.160 24.920 20.440 ;
        RECT 1.960 19.880 8.120 20.160 ;
      LAYER met1 ;
        RECT 8.120 19.880 18.480 20.160 ;
      LAYER met1 ;
        RECT 18.480 19.880 24.920 20.160 ;
      LAYER met1 ;
        RECT 24.920 19.880 26.040 20.440 ;
      LAYER met1 ;
        RECT 26.040 19.880 26.880 20.720 ;
        RECT 0.000 19.600 1.680 19.880 ;
      LAYER met1 ;
        RECT 1.680 19.600 2.240 19.880 ;
      LAYER met1 ;
        RECT 2.240 19.600 7.560 19.880 ;
      LAYER met1 ;
        RECT 7.560 19.600 19.040 19.880 ;
      LAYER met1 ;
        RECT 19.040 19.600 24.640 19.880 ;
      LAYER met1 ;
        RECT 24.640 19.600 25.200 19.880 ;
      LAYER met1 ;
        RECT 25.200 19.600 26.880 19.880 ;
        RECT 0.000 19.320 1.960 19.600 ;
      LAYER met1 ;
        RECT 1.960 19.320 2.520 19.600 ;
      LAYER met1 ;
        RECT 2.520 19.320 7.280 19.600 ;
      LAYER met1 ;
        RECT 7.280 19.320 19.320 19.600 ;
      LAYER met1 ;
        RECT 19.320 19.320 24.360 19.600 ;
      LAYER met1 ;
        RECT 24.360 19.320 24.920 19.600 ;
      LAYER met1 ;
        RECT 24.920 19.320 26.880 19.600 ;
        RECT 0.000 19.040 2.240 19.320 ;
      LAYER met1 ;
        RECT 2.240 19.040 2.800 19.320 ;
      LAYER met1 ;
        RECT 2.800 19.040 7.000 19.320 ;
      LAYER met1 ;
        RECT 7.000 19.040 19.600 19.320 ;
      LAYER met1 ;
        RECT 19.600 19.040 24.080 19.320 ;
      LAYER met1 ;
        RECT 24.080 19.040 24.640 19.320 ;
      LAYER met1 ;
        RECT 24.640 19.040 26.880 19.320 ;
        RECT 0.000 18.760 2.520 19.040 ;
      LAYER met1 ;
        RECT 2.520 18.760 3.080 19.040 ;
      LAYER met1 ;
        RECT 3.080 18.760 7.000 19.040 ;
      LAYER met1 ;
        RECT 7.000 18.760 8.680 19.040 ;
      LAYER met1 ;
        RECT 8.680 18.760 17.920 19.040 ;
      LAYER met1 ;
        RECT 17.920 18.760 19.600 19.040 ;
      LAYER met1 ;
        RECT 19.600 18.760 23.800 19.040 ;
      LAYER met1 ;
        RECT 23.800 18.760 24.360 19.040 ;
      LAYER met1 ;
        RECT 24.360 18.760 26.880 19.040 ;
        RECT 0.000 18.480 2.800 18.760 ;
      LAYER met1 ;
        RECT 2.800 18.480 3.360 18.760 ;
      LAYER met1 ;
        RECT 3.360 18.480 6.720 18.760 ;
        RECT 0.000 17.640 0.840 18.480 ;
      LAYER met1 ;
        RECT 0.840 18.200 1.680 18.480 ;
      LAYER met1 ;
        RECT 1.680 18.200 3.080 18.480 ;
      LAYER met1 ;
        RECT 3.080 18.200 3.640 18.480 ;
      LAYER met1 ;
        RECT 3.640 18.200 6.720 18.480 ;
      LAYER met1 ;
        RECT 6.720 18.200 8.120 18.760 ;
      LAYER met1 ;
        RECT 8.120 18.200 18.480 18.760 ;
      LAYER met1 ;
        RECT 18.480 18.200 19.880 18.760 ;
      LAYER met1 ;
        RECT 19.880 18.480 23.520 18.760 ;
      LAYER met1 ;
        RECT 23.520 18.480 24.080 18.760 ;
      LAYER met1 ;
        RECT 24.080 18.480 26.880 18.760 ;
        RECT 19.880 18.200 23.240 18.480 ;
      LAYER met1 ;
        RECT 23.240 18.200 23.800 18.480 ;
      LAYER met1 ;
        RECT 23.800 18.200 25.200 18.480 ;
      LAYER met1 ;
        RECT 25.200 18.200 26.040 18.480 ;
        RECT 0.840 17.920 1.960 18.200 ;
      LAYER met1 ;
        RECT 1.960 17.920 3.360 18.200 ;
      LAYER met1 ;
        RECT 3.360 17.920 3.920 18.200 ;
      LAYER met1 ;
        RECT 3.920 17.920 5.320 18.200 ;
      LAYER met1 ;
        RECT 5.320 17.920 7.840 18.200 ;
      LAYER met1 ;
        RECT 7.840 17.920 9.240 18.200 ;
      LAYER met1 ;
        RECT 9.240 17.920 9.800 18.200 ;
      LAYER met1 ;
        RECT 9.800 17.920 18.760 18.200 ;
      LAYER met1 ;
        RECT 18.760 17.920 21.280 18.200 ;
      LAYER met1 ;
        RECT 21.280 17.920 22.960 18.200 ;
      LAYER met1 ;
        RECT 22.960 17.920 23.520 18.200 ;
      LAYER met1 ;
        RECT 23.520 17.920 24.920 18.200 ;
      LAYER met1 ;
        RECT 24.920 17.920 26.040 18.200 ;
        RECT 0.840 17.640 2.240 17.920 ;
      LAYER met1 ;
        RECT 2.240 17.640 3.640 17.920 ;
      LAYER met1 ;
        RECT 3.640 17.640 7.840 17.920 ;
      LAYER met1 ;
        RECT 0.000 17.360 1.960 17.640 ;
      LAYER met1 ;
        RECT 1.960 17.360 2.520 17.640 ;
      LAYER met1 ;
        RECT 2.520 17.360 5.320 17.640 ;
      LAYER met1 ;
        RECT 5.320 17.360 7.840 17.640 ;
      LAYER met1 ;
        RECT 7.840 17.360 8.960 17.920 ;
      LAYER met1 ;
        RECT 8.960 17.360 10.080 17.920 ;
      LAYER met1 ;
        RECT 10.080 17.360 18.760 17.920 ;
      LAYER met1 ;
        RECT 18.760 17.640 23.240 17.920 ;
      LAYER met1 ;
        RECT 23.240 17.640 24.640 17.920 ;
      LAYER met1 ;
        RECT 24.640 17.640 26.040 17.920 ;
      LAYER met1 ;
        RECT 26.040 17.640 26.880 18.480 ;
      LAYER met1 ;
        RECT 18.760 17.360 21.280 17.640 ;
      LAYER met1 ;
        RECT 21.280 17.360 24.360 17.640 ;
      LAYER met1 ;
        RECT 24.360 17.360 24.920 17.640 ;
      LAYER met1 ;
        RECT 24.920 17.360 26.880 17.640 ;
        RECT 0.000 17.080 2.240 17.360 ;
      LAYER met1 ;
        RECT 2.240 17.080 2.800 17.360 ;
      LAYER met1 ;
        RECT 2.800 17.080 6.720 17.360 ;
        RECT 0.000 16.800 2.520 17.080 ;
      LAYER met1 ;
        RECT 2.520 16.800 3.080 17.080 ;
      LAYER met1 ;
        RECT 3.080 16.800 6.720 17.080 ;
      LAYER met1 ;
        RECT 6.720 16.800 7.840 17.360 ;
      LAYER met1 ;
        RECT 7.840 17.080 9.240 17.360 ;
      LAYER met1 ;
        RECT 9.240 17.080 9.800 17.360 ;
      LAYER met1 ;
        RECT 9.800 17.080 18.760 17.360 ;
        RECT 0.000 16.520 2.800 16.800 ;
      LAYER met1 ;
        RECT 2.800 16.520 3.360 16.800 ;
      LAYER met1 ;
        RECT 3.360 16.520 5.320 16.800 ;
      LAYER met1 ;
        RECT 5.320 16.520 7.840 16.800 ;
      LAYER met1 ;
        RECT 0.000 16.240 3.080 16.520 ;
      LAYER met1 ;
        RECT 3.080 16.240 7.840 16.520 ;
      LAYER met1 ;
        RECT 0.000 15.400 0.840 16.240 ;
      LAYER met1 ;
        RECT 0.840 15.960 1.680 16.240 ;
      LAYER met1 ;
        RECT 1.680 15.960 5.320 16.240 ;
      LAYER met1 ;
        RECT 5.320 15.960 7.840 16.240 ;
        RECT 0.840 15.680 1.960 15.960 ;
      LAYER met1 ;
        RECT 1.960 15.680 6.720 15.960 ;
      LAYER met1 ;
        RECT 0.840 15.400 2.520 15.680 ;
      LAYER met1 ;
        RECT 2.520 15.400 6.720 15.680 ;
      LAYER met1 ;
        RECT 6.720 15.400 7.840 15.960 ;
      LAYER met1 ;
        RECT 7.840 15.680 18.760 17.080 ;
      LAYER met1 ;
        RECT 18.760 16.800 19.880 17.360 ;
      LAYER met1 ;
        RECT 19.880 17.080 24.080 17.360 ;
      LAYER met1 ;
        RECT 24.080 17.080 24.640 17.360 ;
      LAYER met1 ;
        RECT 24.640 17.080 26.880 17.360 ;
        RECT 19.880 16.800 23.800 17.080 ;
      LAYER met1 ;
        RECT 23.800 16.800 24.360 17.080 ;
      LAYER met1 ;
        RECT 24.360 16.800 26.880 17.080 ;
      LAYER met1 ;
        RECT 18.760 16.520 21.280 16.800 ;
      LAYER met1 ;
        RECT 21.280 16.520 23.520 16.800 ;
      LAYER met1 ;
        RECT 23.520 16.520 24.080 16.800 ;
      LAYER met1 ;
        RECT 24.080 16.520 26.880 16.800 ;
      LAYER met1 ;
        RECT 18.760 16.240 23.800 16.520 ;
      LAYER met1 ;
        RECT 23.800 16.240 26.880 16.520 ;
      LAYER met1 ;
        RECT 18.760 15.960 21.280 16.240 ;
      LAYER met1 ;
        RECT 21.280 15.960 25.200 16.240 ;
      LAYER met1 ;
        RECT 25.200 15.960 26.040 16.240 ;
      LAYER met1 ;
        RECT 7.840 15.400 10.080 15.680 ;
      LAYER met1 ;
        RECT 10.080 15.400 11.480 15.680 ;
      LAYER met1 ;
        RECT 11.480 15.400 18.760 15.680 ;
      LAYER met1 ;
        RECT 18.760 15.400 19.880 15.960 ;
      LAYER met1 ;
        RECT 19.880 15.680 24.920 15.960 ;
      LAYER met1 ;
        RECT 24.920 15.680 26.040 15.960 ;
      LAYER met1 ;
        RECT 19.880 15.400 24.360 15.680 ;
      LAYER met1 ;
        RECT 24.360 15.400 26.040 15.680 ;
      LAYER met1 ;
        RECT 26.040 15.400 26.880 16.240 ;
        RECT 0.000 15.120 2.240 15.400 ;
      LAYER met1 ;
        RECT 2.240 15.120 3.080 15.400 ;
      LAYER met1 ;
        RECT 3.080 15.120 5.320 15.400 ;
      LAYER met1 ;
        RECT 5.320 15.120 7.840 15.400 ;
      LAYER met1 ;
        RECT 7.840 15.120 9.800 15.400 ;
      LAYER met1 ;
        RECT 9.800 15.120 12.040 15.400 ;
      LAYER met1 ;
        RECT 12.040 15.120 18.760 15.400 ;
      LAYER met1 ;
        RECT 18.760 15.120 21.280 15.400 ;
      LAYER met1 ;
        RECT 21.280 15.120 23.800 15.400 ;
      LAYER met1 ;
        RECT 23.800 15.120 24.640 15.400 ;
      LAYER met1 ;
        RECT 24.640 15.120 26.880 15.400 ;
        RECT 0.000 14.840 2.800 15.120 ;
      LAYER met1 ;
        RECT 2.800 14.840 7.840 15.120 ;
      LAYER met1 ;
        RECT 0.000 14.560 5.320 14.840 ;
      LAYER met1 ;
        RECT 5.320 14.560 7.840 14.840 ;
      LAYER met1 ;
        RECT 7.840 14.560 9.240 15.120 ;
      LAYER met1 ;
        RECT 9.240 14.840 10.080 15.120 ;
      LAYER met1 ;
        RECT 10.080 14.840 11.760 15.120 ;
      LAYER met1 ;
        RECT 11.760 14.840 12.320 15.120 ;
      LAYER met1 ;
        RECT 12.320 14.840 18.760 15.120 ;
      LAYER met1 ;
        RECT 18.760 14.840 24.080 15.120 ;
      LAYER met1 ;
        RECT 24.080 14.840 26.880 15.120 ;
      LAYER met1 ;
        RECT 9.240 14.560 9.520 14.840 ;
      LAYER met1 ;
        RECT 9.520 14.560 12.040 14.840 ;
      LAYER met1 ;
        RECT 12.040 14.560 12.600 14.840 ;
      LAYER met1 ;
        RECT 12.600 14.560 18.760 14.840 ;
      LAYER met1 ;
        RECT 18.760 14.560 21.280 14.840 ;
      LAYER met1 ;
        RECT 21.280 14.560 26.880 14.840 ;
        RECT 0.000 14.000 6.720 14.560 ;
      LAYER met1 ;
        RECT 6.720 14.000 7.840 14.560 ;
      LAYER met1 ;
        RECT 7.840 14.280 8.960 14.560 ;
      LAYER met1 ;
        RECT 8.960 14.280 9.520 14.560 ;
      LAYER met1 ;
        RECT 9.520 14.280 12.320 14.560 ;
      LAYER met1 ;
        RECT 12.320 14.280 12.880 14.560 ;
      LAYER met1 ;
        RECT 12.880 14.280 18.760 14.560 ;
        RECT 0.000 13.160 0.840 14.000 ;
      LAYER met1 ;
        RECT 0.840 13.720 1.680 14.000 ;
      LAYER met1 ;
        RECT 1.680 13.720 5.320 14.000 ;
      LAYER met1 ;
        RECT 5.320 13.720 7.840 14.000 ;
        RECT 0.840 13.440 7.840 13.720 ;
        RECT 0.840 13.160 1.680 13.440 ;
      LAYER met1 ;
        RECT 1.680 13.160 5.320 13.440 ;
      LAYER met1 ;
        RECT 5.320 13.160 7.840 13.440 ;
      LAYER met1 ;
        RECT 0.000 12.600 6.720 13.160 ;
      LAYER met1 ;
        RECT 6.720 12.600 7.840 13.160 ;
      LAYER met1 ;
        RECT 0.000 12.320 5.320 12.600 ;
      LAYER met1 ;
        RECT 5.320 12.320 7.840 12.600 ;
      LAYER met1 ;
        RECT 7.840 12.320 8.680 14.280 ;
      LAYER met1 ;
        RECT 8.680 13.720 9.240 14.280 ;
      LAYER met1 ;
        RECT 9.240 14.000 12.600 14.280 ;
      LAYER met1 ;
        RECT 12.600 14.000 17.920 14.280 ;
      LAYER met1 ;
        RECT 17.920 14.000 18.760 14.280 ;
      LAYER met1 ;
        RECT 18.760 14.000 19.880 14.560 ;
      LAYER met1 ;
        RECT 19.880 14.000 26.880 14.560 ;
        RECT 9.240 13.720 9.520 14.000 ;
      LAYER met1 ;
        RECT 9.520 13.720 10.360 14.000 ;
      LAYER met1 ;
        RECT 10.360 13.720 17.640 14.000 ;
      LAYER met1 ;
        RECT 17.640 13.720 18.200 14.000 ;
      LAYER met1 ;
        RECT 18.200 13.720 18.760 14.000 ;
      LAYER met1 ;
        RECT 18.760 13.720 21.280 14.000 ;
      LAYER met1 ;
        RECT 21.280 13.720 25.200 14.000 ;
      LAYER met1 ;
        RECT 25.200 13.720 26.040 14.000 ;
        RECT 8.680 12.880 8.960 13.720 ;
      LAYER met1 ;
        RECT 8.960 12.880 9.520 13.720 ;
      LAYER met1 ;
        RECT 9.520 13.160 9.800 13.720 ;
      LAYER met1 ;
        RECT 9.800 13.160 10.080 13.720 ;
      LAYER met1 ;
        RECT 10.080 13.160 10.360 13.720 ;
      LAYER met1 ;
        RECT 10.360 13.160 17.920 13.720 ;
      LAYER met1 ;
        RECT 17.920 13.160 18.480 13.720 ;
      LAYER met1 ;
        RECT 18.480 13.160 18.760 13.720 ;
      LAYER met1 ;
        RECT 18.760 13.440 26.040 13.720 ;
        RECT 18.760 13.160 21.280 13.440 ;
      LAYER met1 ;
        RECT 21.280 13.160 25.200 13.440 ;
      LAYER met1 ;
        RECT 25.200 13.160 26.040 13.440 ;
      LAYER met1 ;
        RECT 26.040 13.160 26.880 14.000 ;
      LAYER met1 ;
        RECT 9.520 12.880 10.360 13.160 ;
      LAYER met1 ;
        RECT 10.360 12.880 13.720 13.160 ;
      LAYER met1 ;
        RECT 13.720 12.880 14.560 13.160 ;
      LAYER met1 ;
        RECT 14.560 12.880 14.840 13.160 ;
      LAYER met1 ;
        RECT 14.840 12.880 15.680 13.160 ;
      LAYER met1 ;
        RECT 15.680 12.880 15.960 13.160 ;
      LAYER met1 ;
        RECT 15.960 12.880 16.800 13.160 ;
      LAYER met1 ;
        RECT 16.800 12.880 17.640 13.160 ;
      LAYER met1 ;
        RECT 17.640 12.880 18.200 13.160 ;
      LAYER met1 ;
        RECT 18.200 12.880 18.760 13.160 ;
      LAYER met1 ;
        RECT 8.680 12.320 9.240 12.880 ;
      LAYER met1 ;
        RECT 9.240 12.600 12.600 12.880 ;
      LAYER met1 ;
        RECT 12.600 12.600 14.000 12.880 ;
      LAYER met1 ;
        RECT 14.000 12.600 14.280 12.880 ;
      LAYER met1 ;
        RECT 14.280 12.600 15.120 12.880 ;
      LAYER met1 ;
        RECT 15.120 12.600 15.400 12.880 ;
      LAYER met1 ;
        RECT 15.400 12.600 16.240 12.880 ;
      LAYER met1 ;
        RECT 16.240 12.600 16.520 12.880 ;
      LAYER met1 ;
        RECT 16.520 12.600 17.080 12.880 ;
      LAYER met1 ;
        RECT 17.080 12.600 17.360 12.880 ;
      LAYER met1 ;
        RECT 17.360 12.600 17.920 12.880 ;
      LAYER met1 ;
        RECT 17.920 12.600 18.760 12.880 ;
      LAYER met1 ;
        RECT 18.760 12.600 19.880 13.160 ;
      LAYER met1 ;
        RECT 19.880 12.600 26.880 13.160 ;
        RECT 9.240 12.320 12.320 12.600 ;
      LAYER met1 ;
        RECT 12.320 12.320 13.720 12.600 ;
      LAYER met1 ;
        RECT 13.720 12.320 14.560 12.600 ;
      LAYER met1 ;
        RECT 14.560 12.320 14.840 12.600 ;
      LAYER met1 ;
        RECT 14.840 12.320 16.800 12.600 ;
      LAYER met1 ;
        RECT 16.800 12.320 17.640 12.600 ;
      LAYER met1 ;
        RECT 17.640 12.320 18.760 12.600 ;
      LAYER met1 ;
        RECT 18.760 12.320 21.280 12.600 ;
      LAYER met1 ;
        RECT 21.280 12.320 26.880 12.600 ;
        RECT 0.000 12.040 2.800 12.320 ;
      LAYER met1 ;
        RECT 2.800 12.040 7.840 12.320 ;
      LAYER met1 ;
        RECT 7.840 12.040 8.960 12.320 ;
      LAYER met1 ;
        RECT 8.960 12.040 9.520 12.320 ;
      LAYER met1 ;
        RECT 9.520 12.040 12.320 12.320 ;
      LAYER met1 ;
        RECT 12.320 12.040 12.880 12.320 ;
      LAYER met1 ;
        RECT 12.880 12.040 18.760 12.320 ;
      LAYER met1 ;
        RECT 18.760 12.040 24.080 12.320 ;
      LAYER met1 ;
        RECT 24.080 12.040 26.880 12.320 ;
        RECT 0.000 11.760 2.240 12.040 ;
      LAYER met1 ;
        RECT 2.240 11.760 3.080 12.040 ;
      LAYER met1 ;
        RECT 3.080 11.760 5.320 12.040 ;
      LAYER met1 ;
        RECT 5.320 11.760 7.840 12.040 ;
      LAYER met1 ;
        RECT 7.840 11.760 9.240 12.040 ;
      LAYER met1 ;
        RECT 9.240 11.760 9.800 12.040 ;
      LAYER met1 ;
        RECT 9.800 11.760 12.040 12.040 ;
      LAYER met1 ;
        RECT 12.040 11.760 12.600 12.040 ;
      LAYER met1 ;
        RECT 12.600 11.760 18.760 12.040 ;
      LAYER met1 ;
        RECT 18.760 11.760 21.280 12.040 ;
      LAYER met1 ;
        RECT 21.280 11.760 23.800 12.040 ;
      LAYER met1 ;
        RECT 23.800 11.760 24.640 12.040 ;
      LAYER met1 ;
        RECT 24.640 11.760 26.880 12.040 ;
        RECT 0.000 10.920 0.840 11.760 ;
      LAYER met1 ;
        RECT 0.840 11.480 2.520 11.760 ;
      LAYER met1 ;
        RECT 2.520 11.480 6.720 11.760 ;
      LAYER met1 ;
        RECT 0.840 11.200 1.960 11.480 ;
      LAYER met1 ;
        RECT 1.960 11.200 6.720 11.480 ;
      LAYER met1 ;
        RECT 6.720 11.200 7.840 11.760 ;
      LAYER met1 ;
        RECT 7.840 11.480 9.520 11.760 ;
      LAYER met1 ;
        RECT 9.520 11.480 10.080 11.760 ;
      LAYER met1 ;
        RECT 10.080 11.480 11.480 11.760 ;
      LAYER met1 ;
        RECT 11.480 11.480 12.320 11.760 ;
      LAYER met1 ;
        RECT 12.320 11.480 18.760 11.760 ;
        RECT 7.840 11.200 9.800 11.480 ;
      LAYER met1 ;
        RECT 9.800 11.200 12.040 11.480 ;
      LAYER met1 ;
        RECT 12.040 11.200 18.760 11.480 ;
      LAYER met1 ;
        RECT 18.760 11.200 19.880 11.760 ;
      LAYER met1 ;
        RECT 19.880 11.480 24.360 11.760 ;
      LAYER met1 ;
        RECT 24.360 11.480 26.040 11.760 ;
      LAYER met1 ;
        RECT 19.880 11.200 24.920 11.480 ;
      LAYER met1 ;
        RECT 24.920 11.200 26.040 11.480 ;
        RECT 0.840 10.920 1.680 11.200 ;
      LAYER met1 ;
        RECT 1.680 10.920 5.320 11.200 ;
      LAYER met1 ;
        RECT 5.320 10.920 7.840 11.200 ;
      LAYER met1 ;
        RECT 7.840 10.920 10.360 11.200 ;
      LAYER met1 ;
        RECT 10.360 10.920 11.480 11.200 ;
      LAYER met1 ;
        RECT 11.480 10.920 18.760 11.200 ;
      LAYER met1 ;
        RECT 18.760 10.920 21.280 11.200 ;
      LAYER met1 ;
        RECT 21.280 10.920 25.200 11.200 ;
      LAYER met1 ;
        RECT 25.200 10.920 26.040 11.200 ;
      LAYER met1 ;
        RECT 26.040 10.920 26.880 11.760 ;
        RECT 0.000 10.640 3.080 10.920 ;
      LAYER met1 ;
        RECT 3.080 10.640 7.840 10.920 ;
      LAYER met1 ;
        RECT 0.000 10.360 2.800 10.640 ;
      LAYER met1 ;
        RECT 2.800 10.360 3.360 10.640 ;
      LAYER met1 ;
        RECT 3.360 10.360 5.320 10.640 ;
      LAYER met1 ;
        RECT 5.320 10.360 7.840 10.640 ;
      LAYER met1 ;
        RECT 0.000 10.080 2.520 10.360 ;
      LAYER met1 ;
        RECT 2.520 10.080 3.080 10.360 ;
      LAYER met1 ;
        RECT 3.080 10.080 6.720 10.360 ;
        RECT 0.000 9.800 2.240 10.080 ;
      LAYER met1 ;
        RECT 2.240 9.800 2.800 10.080 ;
      LAYER met1 ;
        RECT 2.800 9.800 6.720 10.080 ;
      LAYER met1 ;
        RECT 6.720 9.800 7.840 10.360 ;
      LAYER met1 ;
        RECT 0.000 9.520 1.960 9.800 ;
      LAYER met1 ;
        RECT 1.960 9.520 2.520 9.800 ;
      LAYER met1 ;
        RECT 2.520 9.520 5.320 9.800 ;
      LAYER met1 ;
        RECT 5.320 9.520 7.840 9.800 ;
      LAYER met1 ;
        RECT 0.000 8.680 0.840 9.520 ;
      LAYER met1 ;
        RECT 0.840 9.240 2.240 9.520 ;
      LAYER met1 ;
        RECT 2.240 9.240 3.640 9.520 ;
      LAYER met1 ;
        RECT 3.640 9.240 7.840 9.520 ;
        RECT 0.840 8.960 1.960 9.240 ;
      LAYER met1 ;
        RECT 1.960 8.960 3.360 9.240 ;
      LAYER met1 ;
        RECT 3.360 8.960 3.920 9.240 ;
      LAYER met1 ;
        RECT 3.920 8.960 5.320 9.240 ;
      LAYER met1 ;
        RECT 5.320 8.960 7.840 9.240 ;
      LAYER met1 ;
        RECT 7.840 8.960 18.760 10.920 ;
      LAYER met1 ;
        RECT 18.760 10.640 23.800 10.920 ;
      LAYER met1 ;
        RECT 23.800 10.640 26.880 10.920 ;
      LAYER met1 ;
        RECT 18.760 10.360 21.280 10.640 ;
      LAYER met1 ;
        RECT 21.280 10.360 23.520 10.640 ;
      LAYER met1 ;
        RECT 23.520 10.360 24.080 10.640 ;
      LAYER met1 ;
        RECT 24.080 10.360 26.880 10.640 ;
      LAYER met1 ;
        RECT 18.760 9.800 19.880 10.360 ;
      LAYER met1 ;
        RECT 19.880 10.080 23.800 10.360 ;
      LAYER met1 ;
        RECT 23.800 10.080 24.360 10.360 ;
      LAYER met1 ;
        RECT 24.360 10.080 26.880 10.360 ;
        RECT 19.880 9.800 24.080 10.080 ;
      LAYER met1 ;
        RECT 24.080 9.800 24.640 10.080 ;
      LAYER met1 ;
        RECT 24.640 9.800 26.880 10.080 ;
      LAYER met1 ;
        RECT 18.760 9.520 21.280 9.800 ;
      LAYER met1 ;
        RECT 21.280 9.520 24.360 9.800 ;
      LAYER met1 ;
        RECT 24.360 9.520 24.920 9.800 ;
      LAYER met1 ;
        RECT 24.920 9.520 26.880 9.800 ;
      LAYER met1 ;
        RECT 18.760 9.240 23.240 9.520 ;
      LAYER met1 ;
        RECT 23.240 9.240 24.640 9.520 ;
      LAYER met1 ;
        RECT 24.640 9.240 26.040 9.520 ;
        RECT 18.760 8.960 21.280 9.240 ;
      LAYER met1 ;
        RECT 21.280 8.960 22.960 9.240 ;
      LAYER met1 ;
        RECT 22.960 8.960 23.520 9.240 ;
      LAYER met1 ;
        RECT 23.520 8.960 24.920 9.240 ;
      LAYER met1 ;
        RECT 24.920 8.960 26.040 9.240 ;
        RECT 0.840 8.680 1.680 8.960 ;
      LAYER met1 ;
        RECT 1.680 8.680 3.080 8.960 ;
      LAYER met1 ;
        RECT 3.080 8.680 3.640 8.960 ;
      LAYER met1 ;
        RECT 3.640 8.680 6.720 8.960 ;
        RECT 0.000 8.400 2.800 8.680 ;
      LAYER met1 ;
        RECT 2.800 8.400 3.360 8.680 ;
      LAYER met1 ;
        RECT 3.360 8.400 6.720 8.680 ;
      LAYER met1 ;
        RECT 6.720 8.400 8.120 8.960 ;
      LAYER met1 ;
        RECT 8.120 8.400 18.480 8.960 ;
      LAYER met1 ;
        RECT 18.480 8.400 19.880 8.960 ;
      LAYER met1 ;
        RECT 19.880 8.680 23.240 8.960 ;
      LAYER met1 ;
        RECT 23.240 8.680 23.800 8.960 ;
      LAYER met1 ;
        RECT 23.800 8.680 25.200 8.960 ;
      LAYER met1 ;
        RECT 25.200 8.680 26.040 8.960 ;
      LAYER met1 ;
        RECT 26.040 8.680 26.880 9.520 ;
        RECT 19.880 8.400 23.520 8.680 ;
      LAYER met1 ;
        RECT 23.520 8.400 24.080 8.680 ;
      LAYER met1 ;
        RECT 24.080 8.400 26.880 8.680 ;
        RECT 0.000 8.120 2.520 8.400 ;
      LAYER met1 ;
        RECT 2.520 8.120 3.080 8.400 ;
      LAYER met1 ;
        RECT 3.080 8.120 7.000 8.400 ;
      LAYER met1 ;
        RECT 7.000 8.120 8.680 8.400 ;
      LAYER met1 ;
        RECT 8.680 8.120 17.920 8.400 ;
      LAYER met1 ;
        RECT 17.920 8.120 19.600 8.400 ;
      LAYER met1 ;
        RECT 19.600 8.120 23.800 8.400 ;
      LAYER met1 ;
        RECT 23.800 8.120 24.360 8.400 ;
      LAYER met1 ;
        RECT 24.360 8.120 26.880 8.400 ;
        RECT 0.000 7.840 2.240 8.120 ;
      LAYER met1 ;
        RECT 2.240 7.840 2.800 8.120 ;
      LAYER met1 ;
        RECT 2.800 7.840 7.000 8.120 ;
      LAYER met1 ;
        RECT 7.000 7.840 19.600 8.120 ;
      LAYER met1 ;
        RECT 19.600 7.840 24.080 8.120 ;
      LAYER met1 ;
        RECT 24.080 7.840 24.640 8.120 ;
      LAYER met1 ;
        RECT 24.640 7.840 26.880 8.120 ;
        RECT 0.000 7.560 1.960 7.840 ;
      LAYER met1 ;
        RECT 1.960 7.560 2.520 7.840 ;
      LAYER met1 ;
        RECT 2.520 7.560 7.280 7.840 ;
      LAYER met1 ;
        RECT 7.280 7.560 19.320 7.840 ;
      LAYER met1 ;
        RECT 19.320 7.560 24.360 7.840 ;
      LAYER met1 ;
        RECT 24.360 7.560 24.920 7.840 ;
      LAYER met1 ;
        RECT 24.920 7.560 26.880 7.840 ;
        RECT 0.000 7.280 1.680 7.560 ;
      LAYER met1 ;
        RECT 1.680 7.280 2.240 7.560 ;
      LAYER met1 ;
        RECT 2.240 7.280 7.560 7.560 ;
      LAYER met1 ;
        RECT 7.560 7.280 19.040 7.560 ;
      LAYER met1 ;
        RECT 19.040 7.280 24.640 7.560 ;
      LAYER met1 ;
        RECT 24.640 7.280 25.200 7.560 ;
      LAYER met1 ;
        RECT 25.200 7.280 26.880 7.560 ;
        RECT 0.000 6.440 0.840 7.280 ;
      LAYER met1 ;
        RECT 0.840 6.720 1.960 7.280 ;
      LAYER met1 ;
        RECT 1.960 7.000 8.120 7.280 ;
      LAYER met1 ;
        RECT 8.120 7.000 18.480 7.280 ;
      LAYER met1 ;
        RECT 18.480 7.000 24.920 7.280 ;
        RECT 1.960 6.720 8.680 7.000 ;
      LAYER met1 ;
        RECT 0.840 6.440 1.680 6.720 ;
      LAYER met1 ;
        RECT 1.680 6.440 8.680 6.720 ;
        RECT 0.000 5.600 8.680 6.440 ;
      LAYER met1 ;
        RECT 8.680 5.600 9.520 7.000 ;
      LAYER met1 ;
        RECT 9.520 5.600 10.080 7.000 ;
      LAYER met1 ;
        RECT 10.080 5.600 10.920 7.000 ;
      LAYER met1 ;
        RECT 10.920 5.600 11.480 7.000 ;
      LAYER met1 ;
        RECT 11.480 5.600 12.320 7.000 ;
      LAYER met1 ;
        RECT 12.320 5.600 12.880 7.000 ;
      LAYER met1 ;
        RECT 12.880 5.600 13.720 7.000 ;
      LAYER met1 ;
        RECT 13.720 5.600 14.280 7.000 ;
      LAYER met1 ;
        RECT 14.280 5.600 15.120 7.000 ;
      LAYER met1 ;
        RECT 15.120 5.600 15.680 7.000 ;
      LAYER met1 ;
        RECT 15.680 5.600 16.520 7.000 ;
      LAYER met1 ;
        RECT 16.520 5.600 17.080 7.000 ;
      LAYER met1 ;
        RECT 17.080 5.600 17.920 7.000 ;
      LAYER met1 ;
        RECT 17.920 6.720 24.920 7.000 ;
      LAYER met1 ;
        RECT 24.920 6.720 26.040 7.280 ;
      LAYER met1 ;
        RECT 17.920 6.440 25.200 6.720 ;
      LAYER met1 ;
        RECT 25.200 6.440 26.040 6.720 ;
      LAYER met1 ;
        RECT 26.040 6.440 26.880 7.280 ;
        RECT 17.920 5.600 26.880 6.440 ;
        RECT 0.000 4.480 8.960 5.600 ;
      LAYER met1 ;
        RECT 8.960 4.480 9.240 5.600 ;
      LAYER met1 ;
        RECT 0.000 4.200 8.680 4.480 ;
      LAYER met1 ;
        RECT 8.680 4.200 9.240 4.480 ;
      LAYER met1 ;
        RECT 9.240 4.200 10.360 5.600 ;
        RECT 0.000 3.920 8.400 4.200 ;
      LAYER met1 ;
        RECT 8.400 3.920 8.960 4.200 ;
      LAYER met1 ;
        RECT 8.960 3.920 10.360 4.200 ;
        RECT 0.000 3.640 8.120 3.920 ;
      LAYER met1 ;
        RECT 8.120 3.640 8.680 3.920 ;
      LAYER met1 ;
        RECT 8.680 3.640 10.360 3.920 ;
        RECT 0.000 3.360 7.840 3.640 ;
      LAYER met1 ;
        RECT 7.840 3.360 8.400 3.640 ;
      LAYER met1 ;
        RECT 8.400 3.360 10.360 3.640 ;
      LAYER met1 ;
        RECT 10.360 3.360 10.640 5.600 ;
      LAYER met1 ;
        RECT 0.000 3.080 7.560 3.360 ;
      LAYER met1 ;
        RECT 7.560 3.080 8.120 3.360 ;
      LAYER met1 ;
        RECT 8.120 3.080 10.080 3.360 ;
      LAYER met1 ;
        RECT 10.080 3.080 10.640 3.360 ;
      LAYER met1 ;
        RECT 10.640 3.080 11.760 5.600 ;
      LAYER met1 ;
        RECT 11.760 3.080 12.040 5.600 ;
      LAYER met1 ;
        RECT 0.000 2.800 7.280 3.080 ;
      LAYER met1 ;
        RECT 7.280 2.800 7.840 3.080 ;
      LAYER met1 ;
        RECT 7.840 2.800 9.520 3.080 ;
      LAYER met1 ;
        RECT 9.520 2.800 10.360 3.080 ;
      LAYER met1 ;
        RECT 10.360 2.800 11.480 3.080 ;
      LAYER met1 ;
        RECT 11.480 2.800 12.040 3.080 ;
      LAYER met1 ;
        RECT 12.040 2.800 13.160 5.600 ;
        RECT 0.000 2.520 7.000 2.800 ;
      LAYER met1 ;
        RECT 7.000 2.520 7.560 2.800 ;
      LAYER met1 ;
        RECT 7.560 2.520 9.240 2.800 ;
      LAYER met1 ;
        RECT 9.240 2.520 9.800 2.800 ;
      LAYER met1 ;
        RECT 9.800 2.520 11.200 2.800 ;
      LAYER met1 ;
        RECT 11.200 2.520 11.760 2.800 ;
      LAYER met1 ;
        RECT 11.760 2.520 13.160 2.800 ;
        RECT 0.000 2.240 6.720 2.520 ;
      LAYER met1 ;
        RECT 6.720 2.240 7.280 2.520 ;
      LAYER met1 ;
        RECT 7.280 2.240 8.960 2.520 ;
      LAYER met1 ;
        RECT 8.960 2.240 9.520 2.520 ;
      LAYER met1 ;
        RECT 9.520 2.240 10.920 2.520 ;
      LAYER met1 ;
        RECT 10.920 2.240 11.480 2.520 ;
      LAYER met1 ;
        RECT 11.480 2.240 13.160 2.520 ;
        RECT 0.000 1.960 6.440 2.240 ;
      LAYER met1 ;
        RECT 6.440 1.960 7.000 2.240 ;
      LAYER met1 ;
        RECT 7.000 1.960 8.680 2.240 ;
      LAYER met1 ;
        RECT 8.680 1.960 9.240 2.240 ;
      LAYER met1 ;
        RECT 9.240 1.960 10.920 2.240 ;
      LAYER met1 ;
        RECT 10.920 1.960 11.200 2.240 ;
      LAYER met1 ;
        RECT 11.200 1.960 13.160 2.240 ;
      LAYER met1 ;
        RECT 13.160 1.960 13.440 5.600 ;
      LAYER met1 ;
        RECT 13.440 2.800 14.560 5.600 ;
      LAYER met1 ;
        RECT 14.560 3.080 14.840 5.600 ;
      LAYER met1 ;
        RECT 14.840 3.080 15.960 5.600 ;
      LAYER met1 ;
        RECT 15.960 3.360 16.240 5.600 ;
      LAYER met1 ;
        RECT 16.240 4.200 17.360 5.600 ;
      LAYER met1 ;
        RECT 17.360 4.480 17.640 5.600 ;
      LAYER met1 ;
        RECT 17.640 4.480 26.880 5.600 ;
      LAYER met1 ;
        RECT 17.360 4.200 17.920 4.480 ;
      LAYER met1 ;
        RECT 17.920 4.200 26.880 4.480 ;
        RECT 16.240 3.920 17.640 4.200 ;
      LAYER met1 ;
        RECT 17.640 3.920 18.200 4.200 ;
      LAYER met1 ;
        RECT 18.200 3.920 26.880 4.200 ;
        RECT 16.240 3.640 17.920 3.920 ;
      LAYER met1 ;
        RECT 17.920 3.640 18.480 3.920 ;
      LAYER met1 ;
        RECT 18.480 3.640 26.880 3.920 ;
        RECT 16.240 3.360 18.200 3.640 ;
      LAYER met1 ;
        RECT 18.200 3.360 18.760 3.640 ;
      LAYER met1 ;
        RECT 18.760 3.360 26.880 3.640 ;
      LAYER met1 ;
        RECT 15.960 3.080 16.520 3.360 ;
      LAYER met1 ;
        RECT 16.520 3.080 18.480 3.360 ;
      LAYER met1 ;
        RECT 18.480 3.080 19.040 3.360 ;
      LAYER met1 ;
        RECT 19.040 3.080 26.880 3.360 ;
      LAYER met1 ;
        RECT 14.560 2.800 15.120 3.080 ;
      LAYER met1 ;
        RECT 15.120 2.800 16.240 3.080 ;
      LAYER met1 ;
        RECT 16.240 2.800 17.080 3.080 ;
      LAYER met1 ;
        RECT 17.080 2.800 18.760 3.080 ;
      LAYER met1 ;
        RECT 18.760 2.800 19.320 3.080 ;
      LAYER met1 ;
        RECT 19.320 2.800 26.880 3.080 ;
        RECT 13.440 2.520 14.840 2.800 ;
      LAYER met1 ;
        RECT 14.840 2.520 15.400 2.800 ;
      LAYER met1 ;
        RECT 15.400 2.520 16.800 2.800 ;
      LAYER met1 ;
        RECT 16.800 2.520 17.360 2.800 ;
      LAYER met1 ;
        RECT 17.360 2.520 19.040 2.800 ;
      LAYER met1 ;
        RECT 19.040 2.520 19.600 2.800 ;
      LAYER met1 ;
        RECT 19.600 2.520 26.880 2.800 ;
        RECT 13.440 2.240 15.120 2.520 ;
      LAYER met1 ;
        RECT 15.120 2.240 15.680 2.520 ;
      LAYER met1 ;
        RECT 15.680 2.240 17.080 2.520 ;
      LAYER met1 ;
        RECT 17.080 2.240 17.640 2.520 ;
      LAYER met1 ;
        RECT 17.640 2.240 19.320 2.520 ;
      LAYER met1 ;
        RECT 19.320 2.240 19.880 2.520 ;
      LAYER met1 ;
        RECT 19.880 2.240 26.880 2.520 ;
        RECT 13.440 1.960 15.400 2.240 ;
      LAYER met1 ;
        RECT 15.400 1.960 15.680 2.240 ;
      LAYER met1 ;
        RECT 15.680 1.960 17.360 2.240 ;
      LAYER met1 ;
        RECT 17.360 1.960 17.920 2.240 ;
      LAYER met1 ;
        RECT 17.920 1.960 19.600 2.240 ;
      LAYER met1 ;
        RECT 19.600 1.960 20.160 2.240 ;
      LAYER met1 ;
        RECT 20.160 1.960 26.880 2.240 ;
        RECT 0.000 1.120 6.160 1.960 ;
      LAYER met1 ;
        RECT 6.160 1.120 7.000 1.960 ;
      LAYER met1 ;
        RECT 7.000 1.120 8.400 1.960 ;
      LAYER met1 ;
        RECT 8.400 1.120 9.240 1.960 ;
      LAYER met1 ;
        RECT 9.240 1.120 10.640 1.960 ;
      LAYER met1 ;
        RECT 10.640 1.120 11.480 1.960 ;
      LAYER met1 ;
        RECT 11.480 1.120 12.880 1.960 ;
      LAYER met1 ;
        RECT 12.880 1.120 13.720 1.960 ;
      LAYER met1 ;
        RECT 13.720 1.120 15.120 1.960 ;
      LAYER met1 ;
        RECT 15.120 1.120 15.960 1.960 ;
      LAYER met1 ;
        RECT 15.960 1.120 17.360 1.960 ;
      LAYER met1 ;
        RECT 17.360 1.120 18.200 1.960 ;
      LAYER met1 ;
        RECT 18.200 1.120 19.600 1.960 ;
      LAYER met1 ;
        RECT 19.600 1.120 20.440 1.960 ;
      LAYER met1 ;
        RECT 20.440 1.120 26.880 1.960 ;
        RECT 0.000 0.000 26.880 1.120 ;
      LAYER met2 ;
        RECT 0.000 25.760 26.880 26.880 ;
        RECT 0.000 24.920 6.160 25.760 ;
      LAYER met2 ;
        RECT 6.160 24.920 7.000 25.760 ;
      LAYER met2 ;
        RECT 7.000 24.920 8.400 25.760 ;
      LAYER met2 ;
        RECT 8.400 24.920 9.240 25.760 ;
      LAYER met2 ;
        RECT 9.240 24.920 10.640 25.760 ;
      LAYER met2 ;
        RECT 10.640 24.920 11.480 25.760 ;
      LAYER met2 ;
        RECT 11.480 24.920 12.880 25.760 ;
      LAYER met2 ;
        RECT 12.880 24.920 13.720 25.760 ;
      LAYER met2 ;
        RECT 13.720 24.920 15.120 25.760 ;
      LAYER met2 ;
        RECT 15.120 24.920 15.960 25.760 ;
      LAYER met2 ;
        RECT 15.960 24.920 17.360 25.760 ;
      LAYER met2 ;
        RECT 17.360 24.920 18.200 25.760 ;
      LAYER met2 ;
        RECT 18.200 24.920 19.600 25.760 ;
      LAYER met2 ;
        RECT 19.600 24.920 20.440 25.760 ;
      LAYER met2 ;
        RECT 20.440 24.920 26.880 25.760 ;
        RECT 0.000 24.640 6.440 24.920 ;
      LAYER met2 ;
        RECT 6.440 24.640 7.000 24.920 ;
      LAYER met2 ;
        RECT 7.000 24.640 8.680 24.920 ;
      LAYER met2 ;
        RECT 8.680 24.640 9.240 24.920 ;
      LAYER met2 ;
        RECT 9.240 24.640 10.920 24.920 ;
      LAYER met2 ;
        RECT 10.920 24.640 11.200 24.920 ;
      LAYER met2 ;
        RECT 11.200 24.640 13.160 24.920 ;
        RECT 0.000 24.360 6.720 24.640 ;
      LAYER met2 ;
        RECT 6.720 24.360 7.280 24.640 ;
      LAYER met2 ;
        RECT 7.280 24.360 8.960 24.640 ;
      LAYER met2 ;
        RECT 8.960 24.360 9.520 24.640 ;
      LAYER met2 ;
        RECT 9.520 24.360 10.920 24.640 ;
      LAYER met2 ;
        RECT 10.920 24.360 11.480 24.640 ;
      LAYER met2 ;
        RECT 11.480 24.360 13.160 24.640 ;
        RECT 0.000 24.080 7.000 24.360 ;
      LAYER met2 ;
        RECT 7.000 24.080 7.560 24.360 ;
      LAYER met2 ;
        RECT 7.560 24.080 9.240 24.360 ;
      LAYER met2 ;
        RECT 9.240 24.080 9.800 24.360 ;
      LAYER met2 ;
        RECT 9.800 24.080 11.200 24.360 ;
      LAYER met2 ;
        RECT 11.200 24.080 11.760 24.360 ;
      LAYER met2 ;
        RECT 11.760 24.080 13.160 24.360 ;
        RECT 0.000 23.800 7.280 24.080 ;
      LAYER met2 ;
        RECT 7.280 23.800 7.840 24.080 ;
      LAYER met2 ;
        RECT 7.840 23.800 9.520 24.080 ;
      LAYER met2 ;
        RECT 9.520 23.800 10.360 24.080 ;
      LAYER met2 ;
        RECT 10.360 23.800 11.480 24.080 ;
      LAYER met2 ;
        RECT 11.480 23.800 12.040 24.080 ;
      LAYER met2 ;
        RECT 0.000 23.520 7.560 23.800 ;
      LAYER met2 ;
        RECT 7.560 23.520 8.120 23.800 ;
      LAYER met2 ;
        RECT 8.120 23.520 10.080 23.800 ;
      LAYER met2 ;
        RECT 10.080 23.520 10.640 23.800 ;
      LAYER met2 ;
        RECT 0.000 23.240 7.840 23.520 ;
      LAYER met2 ;
        RECT 7.840 23.240 8.400 23.520 ;
      LAYER met2 ;
        RECT 8.400 23.240 10.360 23.520 ;
        RECT 0.000 22.960 8.120 23.240 ;
      LAYER met2 ;
        RECT 8.120 22.960 8.680 23.240 ;
      LAYER met2 ;
        RECT 8.680 22.960 10.360 23.240 ;
        RECT 0.000 22.680 8.400 22.960 ;
      LAYER met2 ;
        RECT 8.400 22.680 8.960 22.960 ;
      LAYER met2 ;
        RECT 8.960 22.680 10.360 22.960 ;
        RECT 0.000 22.400 8.680 22.680 ;
      LAYER met2 ;
        RECT 8.680 22.400 9.240 22.680 ;
      LAYER met2 ;
        RECT 0.000 21.560 8.960 22.400 ;
      LAYER met2 ;
        RECT 8.960 21.560 9.240 22.400 ;
      LAYER met2 ;
        RECT 9.240 21.560 10.360 22.680 ;
      LAYER met2 ;
        RECT 10.360 21.560 10.640 23.520 ;
      LAYER met2 ;
        RECT 10.640 21.560 11.760 23.800 ;
      LAYER met2 ;
        RECT 11.760 21.560 12.040 23.800 ;
      LAYER met2 ;
        RECT 12.040 21.560 13.160 24.080 ;
      LAYER met2 ;
        RECT 13.160 21.560 13.440 24.920 ;
      LAYER met2 ;
        RECT 13.440 24.640 15.400 24.920 ;
      LAYER met2 ;
        RECT 15.400 24.640 15.680 24.920 ;
      LAYER met2 ;
        RECT 15.680 24.640 17.360 24.920 ;
      LAYER met2 ;
        RECT 17.360 24.640 17.920 24.920 ;
      LAYER met2 ;
        RECT 17.920 24.640 19.600 24.920 ;
      LAYER met2 ;
        RECT 19.600 24.640 20.160 24.920 ;
      LAYER met2 ;
        RECT 20.160 24.640 26.880 24.920 ;
        RECT 13.440 24.360 15.120 24.640 ;
      LAYER met2 ;
        RECT 15.120 24.360 15.680 24.640 ;
      LAYER met2 ;
        RECT 15.680 24.360 17.080 24.640 ;
      LAYER met2 ;
        RECT 17.080 24.360 17.640 24.640 ;
      LAYER met2 ;
        RECT 17.640 24.360 19.320 24.640 ;
      LAYER met2 ;
        RECT 19.320 24.360 19.880 24.640 ;
      LAYER met2 ;
        RECT 19.880 24.360 26.880 24.640 ;
        RECT 13.440 24.080 14.840 24.360 ;
      LAYER met2 ;
        RECT 14.840 24.080 15.400 24.360 ;
      LAYER met2 ;
        RECT 15.400 24.080 16.800 24.360 ;
      LAYER met2 ;
        RECT 16.800 24.080 17.360 24.360 ;
      LAYER met2 ;
        RECT 17.360 24.080 19.040 24.360 ;
      LAYER met2 ;
        RECT 19.040 24.080 19.600 24.360 ;
      LAYER met2 ;
        RECT 19.600 24.080 26.880 24.360 ;
        RECT 13.440 21.560 14.560 24.080 ;
      LAYER met2 ;
        RECT 14.560 23.800 15.120 24.080 ;
      LAYER met2 ;
        RECT 15.120 23.800 16.240 24.080 ;
      LAYER met2 ;
        RECT 16.240 23.800 17.080 24.080 ;
      LAYER met2 ;
        RECT 17.080 23.800 18.760 24.080 ;
      LAYER met2 ;
        RECT 18.760 23.800 19.320 24.080 ;
      LAYER met2 ;
        RECT 19.320 23.800 26.880 24.080 ;
      LAYER met2 ;
        RECT 14.560 21.560 14.840 23.800 ;
      LAYER met2 ;
        RECT 14.840 21.560 15.960 23.800 ;
      LAYER met2 ;
        RECT 15.960 23.520 16.520 23.800 ;
      LAYER met2 ;
        RECT 16.520 23.520 18.480 23.800 ;
      LAYER met2 ;
        RECT 18.480 23.520 19.040 23.800 ;
      LAYER met2 ;
        RECT 19.040 23.520 26.880 23.800 ;
      LAYER met2 ;
        RECT 15.960 21.560 16.240 23.520 ;
      LAYER met2 ;
        RECT 16.240 23.240 18.200 23.520 ;
      LAYER met2 ;
        RECT 18.200 23.240 18.760 23.520 ;
      LAYER met2 ;
        RECT 18.760 23.240 26.880 23.520 ;
        RECT 16.240 22.960 17.920 23.240 ;
      LAYER met2 ;
        RECT 17.920 22.960 18.480 23.240 ;
      LAYER met2 ;
        RECT 18.480 22.960 26.880 23.240 ;
        RECT 16.240 22.680 17.640 22.960 ;
      LAYER met2 ;
        RECT 17.640 22.680 18.200 22.960 ;
      LAYER met2 ;
        RECT 18.200 22.680 26.880 22.960 ;
        RECT 16.240 21.560 17.360 22.680 ;
      LAYER met2 ;
        RECT 17.360 22.400 17.920 22.680 ;
      LAYER met2 ;
        RECT 17.920 22.400 26.880 22.680 ;
      LAYER met2 ;
        RECT 17.360 21.560 17.640 22.400 ;
      LAYER met2 ;
        RECT 17.640 21.560 26.880 22.400 ;
        RECT 0.000 20.720 8.680 21.560 ;
        RECT 0.000 19.880 0.840 20.720 ;
      LAYER met2 ;
        RECT 0.840 20.440 1.680 20.720 ;
      LAYER met2 ;
        RECT 1.680 20.440 8.680 20.720 ;
      LAYER met2 ;
        RECT 0.840 19.880 1.960 20.440 ;
      LAYER met2 ;
        RECT 1.960 20.160 8.680 20.440 ;
      LAYER met2 ;
        RECT 8.680 20.160 9.520 21.560 ;
      LAYER met2 ;
        RECT 9.520 20.160 10.080 21.560 ;
      LAYER met2 ;
        RECT 10.080 20.160 10.920 21.560 ;
      LAYER met2 ;
        RECT 10.920 20.160 11.480 21.560 ;
      LAYER met2 ;
        RECT 11.480 20.160 12.320 21.560 ;
      LAYER met2 ;
        RECT 12.320 20.160 12.880 21.560 ;
      LAYER met2 ;
        RECT 12.880 20.160 13.720 21.560 ;
      LAYER met2 ;
        RECT 13.720 20.160 14.280 21.560 ;
      LAYER met2 ;
        RECT 14.280 20.160 15.120 21.560 ;
      LAYER met2 ;
        RECT 15.120 20.160 15.680 21.560 ;
      LAYER met2 ;
        RECT 15.680 20.160 16.520 21.560 ;
      LAYER met2 ;
        RECT 16.520 20.160 17.080 21.560 ;
      LAYER met2 ;
        RECT 17.080 20.160 17.920 21.560 ;
      LAYER met2 ;
        RECT 17.920 20.720 26.880 21.560 ;
        RECT 17.920 20.440 25.200 20.720 ;
      LAYER met2 ;
        RECT 25.200 20.440 26.040 20.720 ;
      LAYER met2 ;
        RECT 17.920 20.160 24.920 20.440 ;
        RECT 1.960 19.880 8.120 20.160 ;
      LAYER met2 ;
        RECT 8.120 19.880 18.480 20.160 ;
      LAYER met2 ;
        RECT 18.480 19.880 24.920 20.160 ;
      LAYER met2 ;
        RECT 24.920 19.880 26.040 20.440 ;
      LAYER met2 ;
        RECT 26.040 19.880 26.880 20.720 ;
        RECT 0.000 19.600 1.680 19.880 ;
      LAYER met2 ;
        RECT 1.680 19.600 2.240 19.880 ;
      LAYER met2 ;
        RECT 2.240 19.600 7.560 19.880 ;
      LAYER met2 ;
        RECT 7.560 19.600 19.040 19.880 ;
      LAYER met2 ;
        RECT 19.040 19.600 24.640 19.880 ;
      LAYER met2 ;
        RECT 24.640 19.600 25.200 19.880 ;
      LAYER met2 ;
        RECT 25.200 19.600 26.880 19.880 ;
        RECT 0.000 19.320 1.960 19.600 ;
      LAYER met2 ;
        RECT 1.960 19.320 2.520 19.600 ;
      LAYER met2 ;
        RECT 2.520 19.320 7.280 19.600 ;
      LAYER met2 ;
        RECT 7.280 19.320 19.320 19.600 ;
      LAYER met2 ;
        RECT 19.320 19.320 24.360 19.600 ;
      LAYER met2 ;
        RECT 24.360 19.320 24.920 19.600 ;
      LAYER met2 ;
        RECT 24.920 19.320 26.880 19.600 ;
        RECT 0.000 19.040 2.240 19.320 ;
      LAYER met2 ;
        RECT 2.240 19.040 2.800 19.320 ;
      LAYER met2 ;
        RECT 2.800 19.040 7.000 19.320 ;
      LAYER met2 ;
        RECT 7.000 19.040 19.600 19.320 ;
      LAYER met2 ;
        RECT 19.600 19.040 24.080 19.320 ;
      LAYER met2 ;
        RECT 24.080 19.040 24.640 19.320 ;
      LAYER met2 ;
        RECT 24.640 19.040 26.880 19.320 ;
        RECT 0.000 18.760 2.520 19.040 ;
      LAYER met2 ;
        RECT 2.520 18.760 3.080 19.040 ;
      LAYER met2 ;
        RECT 3.080 18.760 7.000 19.040 ;
      LAYER met2 ;
        RECT 7.000 18.760 8.680 19.040 ;
      LAYER met2 ;
        RECT 8.680 18.760 17.920 19.040 ;
      LAYER met2 ;
        RECT 17.920 18.760 19.600 19.040 ;
      LAYER met2 ;
        RECT 19.600 18.760 23.800 19.040 ;
      LAYER met2 ;
        RECT 23.800 18.760 24.360 19.040 ;
      LAYER met2 ;
        RECT 24.360 18.760 26.880 19.040 ;
        RECT 0.000 18.480 2.800 18.760 ;
      LAYER met2 ;
        RECT 2.800 18.480 3.360 18.760 ;
      LAYER met2 ;
        RECT 3.360 18.480 6.720 18.760 ;
        RECT 0.000 17.640 0.840 18.480 ;
      LAYER met2 ;
        RECT 0.840 18.200 1.680 18.480 ;
      LAYER met2 ;
        RECT 1.680 18.200 3.080 18.480 ;
      LAYER met2 ;
        RECT 3.080 18.200 3.640 18.480 ;
      LAYER met2 ;
        RECT 3.640 18.200 6.720 18.480 ;
      LAYER met2 ;
        RECT 6.720 18.200 8.120 18.760 ;
      LAYER met2 ;
        RECT 8.120 18.200 18.480 18.760 ;
      LAYER met2 ;
        RECT 18.480 18.200 19.880 18.760 ;
      LAYER met2 ;
        RECT 19.880 18.480 23.520 18.760 ;
      LAYER met2 ;
        RECT 23.520 18.480 24.080 18.760 ;
      LAYER met2 ;
        RECT 24.080 18.480 26.880 18.760 ;
        RECT 19.880 18.200 23.240 18.480 ;
      LAYER met2 ;
        RECT 23.240 18.200 23.800 18.480 ;
      LAYER met2 ;
        RECT 23.800 18.200 25.200 18.480 ;
      LAYER met2 ;
        RECT 25.200 18.200 26.040 18.480 ;
        RECT 0.840 17.920 1.960 18.200 ;
      LAYER met2 ;
        RECT 1.960 17.920 3.360 18.200 ;
      LAYER met2 ;
        RECT 3.360 17.920 3.920 18.200 ;
      LAYER met2 ;
        RECT 3.920 17.920 5.320 18.200 ;
      LAYER met2 ;
        RECT 5.320 17.920 7.840 18.200 ;
      LAYER met2 ;
        RECT 7.840 17.920 9.240 18.200 ;
      LAYER met2 ;
        RECT 9.240 17.920 9.800 18.200 ;
      LAYER met2 ;
        RECT 9.800 17.920 18.760 18.200 ;
      LAYER met2 ;
        RECT 18.760 17.920 21.280 18.200 ;
      LAYER met2 ;
        RECT 21.280 17.920 22.960 18.200 ;
      LAYER met2 ;
        RECT 22.960 17.920 23.520 18.200 ;
      LAYER met2 ;
        RECT 23.520 17.920 24.920 18.200 ;
      LAYER met2 ;
        RECT 24.920 17.920 26.040 18.200 ;
        RECT 0.840 17.640 2.240 17.920 ;
      LAYER met2 ;
        RECT 2.240 17.640 3.640 17.920 ;
      LAYER met2 ;
        RECT 3.640 17.640 7.840 17.920 ;
      LAYER met2 ;
        RECT 0.000 17.360 1.960 17.640 ;
      LAYER met2 ;
        RECT 1.960 17.360 2.520 17.640 ;
      LAYER met2 ;
        RECT 2.520 17.360 5.320 17.640 ;
      LAYER met2 ;
        RECT 5.320 17.360 7.840 17.640 ;
      LAYER met2 ;
        RECT 7.840 17.360 8.960 17.920 ;
      LAYER met2 ;
        RECT 8.960 17.360 10.080 17.920 ;
      LAYER met2 ;
        RECT 10.080 17.360 18.760 17.920 ;
      LAYER met2 ;
        RECT 18.760 17.640 23.240 17.920 ;
      LAYER met2 ;
        RECT 23.240 17.640 24.640 17.920 ;
      LAYER met2 ;
        RECT 24.640 17.640 26.040 17.920 ;
      LAYER met2 ;
        RECT 26.040 17.640 26.880 18.480 ;
      LAYER met2 ;
        RECT 18.760 17.360 21.280 17.640 ;
      LAYER met2 ;
        RECT 21.280 17.360 24.360 17.640 ;
      LAYER met2 ;
        RECT 24.360 17.360 24.920 17.640 ;
      LAYER met2 ;
        RECT 24.920 17.360 26.880 17.640 ;
        RECT 0.000 17.080 2.240 17.360 ;
      LAYER met2 ;
        RECT 2.240 17.080 2.800 17.360 ;
      LAYER met2 ;
        RECT 2.800 17.080 6.720 17.360 ;
        RECT 0.000 16.800 2.520 17.080 ;
      LAYER met2 ;
        RECT 2.520 16.800 3.080 17.080 ;
      LAYER met2 ;
        RECT 3.080 16.800 6.720 17.080 ;
      LAYER met2 ;
        RECT 6.720 16.800 7.840 17.360 ;
      LAYER met2 ;
        RECT 7.840 17.080 9.240 17.360 ;
      LAYER met2 ;
        RECT 9.240 17.080 9.800 17.360 ;
      LAYER met2 ;
        RECT 9.800 17.080 18.760 17.360 ;
        RECT 0.000 16.520 2.800 16.800 ;
      LAYER met2 ;
        RECT 2.800 16.520 3.360 16.800 ;
      LAYER met2 ;
        RECT 3.360 16.520 5.320 16.800 ;
      LAYER met2 ;
        RECT 5.320 16.520 7.840 16.800 ;
      LAYER met2 ;
        RECT 0.000 16.240 3.080 16.520 ;
      LAYER met2 ;
        RECT 3.080 16.240 7.840 16.520 ;
      LAYER met2 ;
        RECT 0.000 15.400 0.840 16.240 ;
      LAYER met2 ;
        RECT 0.840 15.960 1.680 16.240 ;
      LAYER met2 ;
        RECT 1.680 15.960 5.320 16.240 ;
      LAYER met2 ;
        RECT 5.320 15.960 7.840 16.240 ;
        RECT 0.840 15.680 1.960 15.960 ;
      LAYER met2 ;
        RECT 1.960 15.680 6.720 15.960 ;
      LAYER met2 ;
        RECT 0.840 15.400 2.520 15.680 ;
      LAYER met2 ;
        RECT 2.520 15.400 6.720 15.680 ;
      LAYER met2 ;
        RECT 6.720 15.400 7.840 15.960 ;
      LAYER met2 ;
        RECT 7.840 15.680 18.760 17.080 ;
      LAYER met2 ;
        RECT 18.760 16.800 19.880 17.360 ;
      LAYER met2 ;
        RECT 19.880 17.080 24.080 17.360 ;
      LAYER met2 ;
        RECT 24.080 17.080 24.640 17.360 ;
      LAYER met2 ;
        RECT 24.640 17.080 26.880 17.360 ;
        RECT 19.880 16.800 23.800 17.080 ;
      LAYER met2 ;
        RECT 23.800 16.800 24.360 17.080 ;
      LAYER met2 ;
        RECT 24.360 16.800 26.880 17.080 ;
      LAYER met2 ;
        RECT 18.760 16.520 21.280 16.800 ;
      LAYER met2 ;
        RECT 21.280 16.520 23.520 16.800 ;
      LAYER met2 ;
        RECT 23.520 16.520 24.080 16.800 ;
      LAYER met2 ;
        RECT 24.080 16.520 26.880 16.800 ;
      LAYER met2 ;
        RECT 18.760 16.240 23.800 16.520 ;
      LAYER met2 ;
        RECT 23.800 16.240 26.880 16.520 ;
      LAYER met2 ;
        RECT 18.760 15.960 21.280 16.240 ;
      LAYER met2 ;
        RECT 21.280 15.960 25.200 16.240 ;
      LAYER met2 ;
        RECT 25.200 15.960 26.040 16.240 ;
      LAYER met2 ;
        RECT 7.840 15.400 10.080 15.680 ;
      LAYER met2 ;
        RECT 10.080 15.400 11.480 15.680 ;
      LAYER met2 ;
        RECT 11.480 15.400 18.760 15.680 ;
      LAYER met2 ;
        RECT 18.760 15.400 19.880 15.960 ;
      LAYER met2 ;
        RECT 19.880 15.680 24.920 15.960 ;
      LAYER met2 ;
        RECT 24.920 15.680 26.040 15.960 ;
      LAYER met2 ;
        RECT 19.880 15.400 24.360 15.680 ;
      LAYER met2 ;
        RECT 24.360 15.400 26.040 15.680 ;
      LAYER met2 ;
        RECT 26.040 15.400 26.880 16.240 ;
        RECT 0.000 15.120 2.240 15.400 ;
      LAYER met2 ;
        RECT 2.240 15.120 3.080 15.400 ;
      LAYER met2 ;
        RECT 3.080 15.120 5.320 15.400 ;
      LAYER met2 ;
        RECT 5.320 15.120 7.840 15.400 ;
      LAYER met2 ;
        RECT 7.840 15.120 9.800 15.400 ;
      LAYER met2 ;
        RECT 9.800 15.120 12.040 15.400 ;
      LAYER met2 ;
        RECT 12.040 15.120 18.760 15.400 ;
      LAYER met2 ;
        RECT 18.760 15.120 21.280 15.400 ;
      LAYER met2 ;
        RECT 21.280 15.120 23.800 15.400 ;
      LAYER met2 ;
        RECT 23.800 15.120 24.640 15.400 ;
      LAYER met2 ;
        RECT 24.640 15.120 26.880 15.400 ;
        RECT 0.000 14.840 2.800 15.120 ;
      LAYER met2 ;
        RECT 2.800 14.840 7.840 15.120 ;
      LAYER met2 ;
        RECT 0.000 14.560 5.320 14.840 ;
      LAYER met2 ;
        RECT 5.320 14.560 7.840 14.840 ;
      LAYER met2 ;
        RECT 7.840 14.560 9.240 15.120 ;
      LAYER met2 ;
        RECT 9.240 14.840 10.080 15.120 ;
      LAYER met2 ;
        RECT 10.080 14.840 11.760 15.120 ;
      LAYER met2 ;
        RECT 11.760 14.840 12.320 15.120 ;
      LAYER met2 ;
        RECT 12.320 14.840 18.760 15.120 ;
      LAYER met2 ;
        RECT 18.760 14.840 24.080 15.120 ;
      LAYER met2 ;
        RECT 24.080 14.840 26.880 15.120 ;
      LAYER met2 ;
        RECT 9.240 14.560 9.520 14.840 ;
      LAYER met2 ;
        RECT 9.520 14.560 12.040 14.840 ;
      LAYER met2 ;
        RECT 12.040 14.560 12.600 14.840 ;
      LAYER met2 ;
        RECT 12.600 14.560 18.760 14.840 ;
      LAYER met2 ;
        RECT 18.760 14.560 21.280 14.840 ;
      LAYER met2 ;
        RECT 21.280 14.560 26.880 14.840 ;
        RECT 0.000 14.000 6.720 14.560 ;
      LAYER met2 ;
        RECT 6.720 14.000 7.840 14.560 ;
      LAYER met2 ;
        RECT 7.840 14.280 8.960 14.560 ;
      LAYER met2 ;
        RECT 8.960 14.280 9.520 14.560 ;
      LAYER met2 ;
        RECT 9.520 14.280 12.320 14.560 ;
      LAYER met2 ;
        RECT 12.320 14.280 12.880 14.560 ;
      LAYER met2 ;
        RECT 12.880 14.280 18.760 14.560 ;
        RECT 0.000 13.160 0.840 14.000 ;
      LAYER met2 ;
        RECT 0.840 13.720 1.680 14.000 ;
      LAYER met2 ;
        RECT 1.680 13.720 5.320 14.000 ;
      LAYER met2 ;
        RECT 5.320 13.720 7.840 14.000 ;
        RECT 0.840 13.440 7.840 13.720 ;
        RECT 0.840 13.160 1.680 13.440 ;
      LAYER met2 ;
        RECT 1.680 13.160 5.320 13.440 ;
      LAYER met2 ;
        RECT 5.320 13.160 7.840 13.440 ;
      LAYER met2 ;
        RECT 0.000 12.600 6.720 13.160 ;
      LAYER met2 ;
        RECT 6.720 12.600 7.840 13.160 ;
      LAYER met2 ;
        RECT 0.000 12.320 5.320 12.600 ;
      LAYER met2 ;
        RECT 5.320 12.320 7.840 12.600 ;
      LAYER met2 ;
        RECT 7.840 12.320 8.680 14.280 ;
      LAYER met2 ;
        RECT 8.680 13.720 9.240 14.280 ;
      LAYER met2 ;
        RECT 9.240 14.000 12.600 14.280 ;
      LAYER met2 ;
        RECT 12.600 14.000 17.920 14.280 ;
      LAYER met2 ;
        RECT 17.920 14.000 18.760 14.280 ;
      LAYER met2 ;
        RECT 18.760 14.000 19.880 14.560 ;
      LAYER met2 ;
        RECT 19.880 14.000 26.880 14.560 ;
        RECT 9.240 13.720 9.520 14.000 ;
      LAYER met2 ;
        RECT 9.520 13.720 10.360 14.000 ;
      LAYER met2 ;
        RECT 10.360 13.720 17.640 14.000 ;
      LAYER met2 ;
        RECT 17.640 13.720 18.200 14.000 ;
      LAYER met2 ;
        RECT 18.200 13.720 18.760 14.000 ;
      LAYER met2 ;
        RECT 18.760 13.720 21.280 14.000 ;
      LAYER met2 ;
        RECT 21.280 13.720 25.200 14.000 ;
      LAYER met2 ;
        RECT 25.200 13.720 26.040 14.000 ;
        RECT 8.680 12.880 8.960 13.720 ;
      LAYER met2 ;
        RECT 8.960 12.880 9.520 13.720 ;
      LAYER met2 ;
        RECT 9.520 13.160 9.800 13.720 ;
      LAYER met2 ;
        RECT 9.800 13.160 10.080 13.720 ;
      LAYER met2 ;
        RECT 10.080 13.160 10.360 13.720 ;
      LAYER met2 ;
        RECT 10.360 13.160 17.920 13.720 ;
      LAYER met2 ;
        RECT 17.920 13.160 18.480 13.720 ;
      LAYER met2 ;
        RECT 18.480 13.160 18.760 13.720 ;
      LAYER met2 ;
        RECT 18.760 13.440 26.040 13.720 ;
        RECT 18.760 13.160 21.280 13.440 ;
      LAYER met2 ;
        RECT 21.280 13.160 25.200 13.440 ;
      LAYER met2 ;
        RECT 25.200 13.160 26.040 13.440 ;
      LAYER met2 ;
        RECT 26.040 13.160 26.880 14.000 ;
      LAYER met2 ;
        RECT 9.520 12.880 10.360 13.160 ;
      LAYER met2 ;
        RECT 10.360 12.880 13.720 13.160 ;
      LAYER met2 ;
        RECT 13.720 12.880 14.560 13.160 ;
      LAYER met2 ;
        RECT 14.560 12.880 14.840 13.160 ;
      LAYER met2 ;
        RECT 14.840 12.880 15.680 13.160 ;
      LAYER met2 ;
        RECT 15.680 12.880 15.960 13.160 ;
      LAYER met2 ;
        RECT 15.960 12.880 16.800 13.160 ;
      LAYER met2 ;
        RECT 16.800 12.880 17.640 13.160 ;
      LAYER met2 ;
        RECT 17.640 12.880 18.200 13.160 ;
      LAYER met2 ;
        RECT 18.200 12.880 18.760 13.160 ;
      LAYER met2 ;
        RECT 8.680 12.320 9.240 12.880 ;
      LAYER met2 ;
        RECT 9.240 12.600 12.600 12.880 ;
      LAYER met2 ;
        RECT 12.600 12.600 14.000 12.880 ;
      LAYER met2 ;
        RECT 14.000 12.600 14.280 12.880 ;
      LAYER met2 ;
        RECT 14.280 12.600 15.120 12.880 ;
      LAYER met2 ;
        RECT 15.120 12.600 15.400 12.880 ;
      LAYER met2 ;
        RECT 15.400 12.600 16.240 12.880 ;
      LAYER met2 ;
        RECT 16.240 12.600 16.520 12.880 ;
      LAYER met2 ;
        RECT 16.520 12.600 17.080 12.880 ;
      LAYER met2 ;
        RECT 17.080 12.600 17.360 12.880 ;
      LAYER met2 ;
        RECT 17.360 12.600 17.920 12.880 ;
      LAYER met2 ;
        RECT 17.920 12.600 18.760 12.880 ;
      LAYER met2 ;
        RECT 18.760 12.600 19.880 13.160 ;
      LAYER met2 ;
        RECT 19.880 12.600 26.880 13.160 ;
        RECT 9.240 12.320 12.320 12.600 ;
      LAYER met2 ;
        RECT 12.320 12.320 13.720 12.600 ;
      LAYER met2 ;
        RECT 13.720 12.320 14.560 12.600 ;
      LAYER met2 ;
        RECT 14.560 12.320 14.840 12.600 ;
      LAYER met2 ;
        RECT 14.840 12.320 16.800 12.600 ;
      LAYER met2 ;
        RECT 16.800 12.320 17.640 12.600 ;
      LAYER met2 ;
        RECT 17.640 12.320 18.760 12.600 ;
      LAYER met2 ;
        RECT 18.760 12.320 21.280 12.600 ;
      LAYER met2 ;
        RECT 21.280 12.320 26.880 12.600 ;
        RECT 0.000 12.040 2.800 12.320 ;
      LAYER met2 ;
        RECT 2.800 12.040 7.840 12.320 ;
      LAYER met2 ;
        RECT 7.840 12.040 8.960 12.320 ;
      LAYER met2 ;
        RECT 8.960 12.040 9.520 12.320 ;
      LAYER met2 ;
        RECT 9.520 12.040 12.320 12.320 ;
      LAYER met2 ;
        RECT 12.320 12.040 12.880 12.320 ;
      LAYER met2 ;
        RECT 12.880 12.040 18.760 12.320 ;
      LAYER met2 ;
        RECT 18.760 12.040 24.080 12.320 ;
      LAYER met2 ;
        RECT 24.080 12.040 26.880 12.320 ;
        RECT 0.000 11.760 2.240 12.040 ;
      LAYER met2 ;
        RECT 2.240 11.760 3.080 12.040 ;
      LAYER met2 ;
        RECT 3.080 11.760 5.320 12.040 ;
      LAYER met2 ;
        RECT 5.320 11.760 7.840 12.040 ;
      LAYER met2 ;
        RECT 7.840 11.760 9.240 12.040 ;
      LAYER met2 ;
        RECT 9.240 11.760 9.800 12.040 ;
      LAYER met2 ;
        RECT 9.800 11.760 12.040 12.040 ;
      LAYER met2 ;
        RECT 12.040 11.760 12.600 12.040 ;
      LAYER met2 ;
        RECT 12.600 11.760 18.760 12.040 ;
      LAYER met2 ;
        RECT 18.760 11.760 21.280 12.040 ;
      LAYER met2 ;
        RECT 21.280 11.760 23.800 12.040 ;
      LAYER met2 ;
        RECT 23.800 11.760 24.640 12.040 ;
      LAYER met2 ;
        RECT 24.640 11.760 26.880 12.040 ;
        RECT 0.000 10.920 0.840 11.760 ;
      LAYER met2 ;
        RECT 0.840 11.480 2.520 11.760 ;
      LAYER met2 ;
        RECT 2.520 11.480 6.720 11.760 ;
      LAYER met2 ;
        RECT 0.840 11.200 1.960 11.480 ;
      LAYER met2 ;
        RECT 1.960 11.200 6.720 11.480 ;
      LAYER met2 ;
        RECT 6.720 11.200 7.840 11.760 ;
      LAYER met2 ;
        RECT 7.840 11.480 9.520 11.760 ;
      LAYER met2 ;
        RECT 9.520 11.480 10.080 11.760 ;
      LAYER met2 ;
        RECT 10.080 11.480 11.480 11.760 ;
      LAYER met2 ;
        RECT 11.480 11.480 12.320 11.760 ;
      LAYER met2 ;
        RECT 12.320 11.480 18.760 11.760 ;
        RECT 7.840 11.200 9.800 11.480 ;
      LAYER met2 ;
        RECT 9.800 11.200 12.040 11.480 ;
      LAYER met2 ;
        RECT 12.040 11.200 18.760 11.480 ;
      LAYER met2 ;
        RECT 18.760 11.200 19.880 11.760 ;
      LAYER met2 ;
        RECT 19.880 11.480 24.360 11.760 ;
      LAYER met2 ;
        RECT 24.360 11.480 26.040 11.760 ;
      LAYER met2 ;
        RECT 19.880 11.200 24.920 11.480 ;
      LAYER met2 ;
        RECT 24.920 11.200 26.040 11.480 ;
        RECT 0.840 10.920 1.680 11.200 ;
      LAYER met2 ;
        RECT 1.680 10.920 5.320 11.200 ;
      LAYER met2 ;
        RECT 5.320 10.920 7.840 11.200 ;
      LAYER met2 ;
        RECT 7.840 10.920 10.360 11.200 ;
      LAYER met2 ;
        RECT 10.360 10.920 11.480 11.200 ;
      LAYER met2 ;
        RECT 11.480 10.920 18.760 11.200 ;
      LAYER met2 ;
        RECT 18.760 10.920 21.280 11.200 ;
      LAYER met2 ;
        RECT 21.280 10.920 25.200 11.200 ;
      LAYER met2 ;
        RECT 25.200 10.920 26.040 11.200 ;
      LAYER met2 ;
        RECT 26.040 10.920 26.880 11.760 ;
        RECT 0.000 10.640 3.080 10.920 ;
      LAYER met2 ;
        RECT 3.080 10.640 7.840 10.920 ;
      LAYER met2 ;
        RECT 0.000 10.360 2.800 10.640 ;
      LAYER met2 ;
        RECT 2.800 10.360 3.360 10.640 ;
      LAYER met2 ;
        RECT 3.360 10.360 5.320 10.640 ;
      LAYER met2 ;
        RECT 5.320 10.360 7.840 10.640 ;
      LAYER met2 ;
        RECT 0.000 10.080 2.520 10.360 ;
      LAYER met2 ;
        RECT 2.520 10.080 3.080 10.360 ;
      LAYER met2 ;
        RECT 3.080 10.080 6.720 10.360 ;
        RECT 0.000 9.800 2.240 10.080 ;
      LAYER met2 ;
        RECT 2.240 9.800 2.800 10.080 ;
      LAYER met2 ;
        RECT 2.800 9.800 6.720 10.080 ;
      LAYER met2 ;
        RECT 6.720 9.800 7.840 10.360 ;
      LAYER met2 ;
        RECT 0.000 9.520 1.960 9.800 ;
      LAYER met2 ;
        RECT 1.960 9.520 2.520 9.800 ;
      LAYER met2 ;
        RECT 2.520 9.520 5.320 9.800 ;
      LAYER met2 ;
        RECT 5.320 9.520 7.840 9.800 ;
      LAYER met2 ;
        RECT 0.000 8.680 0.840 9.520 ;
      LAYER met2 ;
        RECT 0.840 9.240 2.240 9.520 ;
      LAYER met2 ;
        RECT 2.240 9.240 3.640 9.520 ;
      LAYER met2 ;
        RECT 3.640 9.240 7.840 9.520 ;
        RECT 0.840 8.960 1.960 9.240 ;
      LAYER met2 ;
        RECT 1.960 8.960 3.360 9.240 ;
      LAYER met2 ;
        RECT 3.360 8.960 3.920 9.240 ;
      LAYER met2 ;
        RECT 3.920 8.960 5.320 9.240 ;
      LAYER met2 ;
        RECT 5.320 8.960 7.840 9.240 ;
      LAYER met2 ;
        RECT 7.840 8.960 18.760 10.920 ;
      LAYER met2 ;
        RECT 18.760 10.640 23.800 10.920 ;
      LAYER met2 ;
        RECT 23.800 10.640 26.880 10.920 ;
      LAYER met2 ;
        RECT 18.760 10.360 21.280 10.640 ;
      LAYER met2 ;
        RECT 21.280 10.360 23.520 10.640 ;
      LAYER met2 ;
        RECT 23.520 10.360 24.080 10.640 ;
      LAYER met2 ;
        RECT 24.080 10.360 26.880 10.640 ;
      LAYER met2 ;
        RECT 18.760 9.800 19.880 10.360 ;
      LAYER met2 ;
        RECT 19.880 10.080 23.800 10.360 ;
      LAYER met2 ;
        RECT 23.800 10.080 24.360 10.360 ;
      LAYER met2 ;
        RECT 24.360 10.080 26.880 10.360 ;
        RECT 19.880 9.800 24.080 10.080 ;
      LAYER met2 ;
        RECT 24.080 9.800 24.640 10.080 ;
      LAYER met2 ;
        RECT 24.640 9.800 26.880 10.080 ;
      LAYER met2 ;
        RECT 18.760 9.520 21.280 9.800 ;
      LAYER met2 ;
        RECT 21.280 9.520 24.360 9.800 ;
      LAYER met2 ;
        RECT 24.360 9.520 24.920 9.800 ;
      LAYER met2 ;
        RECT 24.920 9.520 26.880 9.800 ;
      LAYER met2 ;
        RECT 18.760 9.240 23.240 9.520 ;
      LAYER met2 ;
        RECT 23.240 9.240 24.640 9.520 ;
      LAYER met2 ;
        RECT 24.640 9.240 26.040 9.520 ;
        RECT 18.760 8.960 21.280 9.240 ;
      LAYER met2 ;
        RECT 21.280 8.960 22.960 9.240 ;
      LAYER met2 ;
        RECT 22.960 8.960 23.520 9.240 ;
      LAYER met2 ;
        RECT 23.520 8.960 24.920 9.240 ;
      LAYER met2 ;
        RECT 24.920 8.960 26.040 9.240 ;
        RECT 0.840 8.680 1.680 8.960 ;
      LAYER met2 ;
        RECT 1.680 8.680 3.080 8.960 ;
      LAYER met2 ;
        RECT 3.080 8.680 3.640 8.960 ;
      LAYER met2 ;
        RECT 3.640 8.680 6.720 8.960 ;
        RECT 0.000 8.400 2.800 8.680 ;
      LAYER met2 ;
        RECT 2.800 8.400 3.360 8.680 ;
      LAYER met2 ;
        RECT 3.360 8.400 6.720 8.680 ;
      LAYER met2 ;
        RECT 6.720 8.400 8.120 8.960 ;
      LAYER met2 ;
        RECT 8.120 8.400 18.480 8.960 ;
      LAYER met2 ;
        RECT 18.480 8.400 19.880 8.960 ;
      LAYER met2 ;
        RECT 19.880 8.680 23.240 8.960 ;
      LAYER met2 ;
        RECT 23.240 8.680 23.800 8.960 ;
      LAYER met2 ;
        RECT 23.800 8.680 25.200 8.960 ;
      LAYER met2 ;
        RECT 25.200 8.680 26.040 8.960 ;
      LAYER met2 ;
        RECT 26.040 8.680 26.880 9.520 ;
        RECT 19.880 8.400 23.520 8.680 ;
      LAYER met2 ;
        RECT 23.520 8.400 24.080 8.680 ;
      LAYER met2 ;
        RECT 24.080 8.400 26.880 8.680 ;
        RECT 0.000 8.120 2.520 8.400 ;
      LAYER met2 ;
        RECT 2.520 8.120 3.080 8.400 ;
      LAYER met2 ;
        RECT 3.080 8.120 7.000 8.400 ;
      LAYER met2 ;
        RECT 7.000 8.120 8.680 8.400 ;
      LAYER met2 ;
        RECT 8.680 8.120 17.920 8.400 ;
      LAYER met2 ;
        RECT 17.920 8.120 19.600 8.400 ;
      LAYER met2 ;
        RECT 19.600 8.120 23.800 8.400 ;
      LAYER met2 ;
        RECT 23.800 8.120 24.360 8.400 ;
      LAYER met2 ;
        RECT 24.360 8.120 26.880 8.400 ;
        RECT 0.000 7.840 2.240 8.120 ;
      LAYER met2 ;
        RECT 2.240 7.840 2.800 8.120 ;
      LAYER met2 ;
        RECT 2.800 7.840 7.000 8.120 ;
      LAYER met2 ;
        RECT 7.000 7.840 19.600 8.120 ;
      LAYER met2 ;
        RECT 19.600 7.840 24.080 8.120 ;
      LAYER met2 ;
        RECT 24.080 7.840 24.640 8.120 ;
      LAYER met2 ;
        RECT 24.640 7.840 26.880 8.120 ;
        RECT 0.000 7.560 1.960 7.840 ;
      LAYER met2 ;
        RECT 1.960 7.560 2.520 7.840 ;
      LAYER met2 ;
        RECT 2.520 7.560 7.280 7.840 ;
      LAYER met2 ;
        RECT 7.280 7.560 19.320 7.840 ;
      LAYER met2 ;
        RECT 19.320 7.560 24.360 7.840 ;
      LAYER met2 ;
        RECT 24.360 7.560 24.920 7.840 ;
      LAYER met2 ;
        RECT 24.920 7.560 26.880 7.840 ;
        RECT 0.000 7.280 1.680 7.560 ;
      LAYER met2 ;
        RECT 1.680 7.280 2.240 7.560 ;
      LAYER met2 ;
        RECT 2.240 7.280 7.560 7.560 ;
      LAYER met2 ;
        RECT 7.560 7.280 19.040 7.560 ;
      LAYER met2 ;
        RECT 19.040 7.280 24.640 7.560 ;
      LAYER met2 ;
        RECT 24.640 7.280 25.200 7.560 ;
      LAYER met2 ;
        RECT 25.200 7.280 26.880 7.560 ;
        RECT 0.000 6.440 0.840 7.280 ;
      LAYER met2 ;
        RECT 0.840 6.720 1.960 7.280 ;
      LAYER met2 ;
        RECT 1.960 7.000 8.120 7.280 ;
      LAYER met2 ;
        RECT 8.120 7.000 18.480 7.280 ;
      LAYER met2 ;
        RECT 18.480 7.000 24.920 7.280 ;
        RECT 1.960 6.720 8.680 7.000 ;
      LAYER met2 ;
        RECT 0.840 6.440 1.680 6.720 ;
      LAYER met2 ;
        RECT 1.680 6.440 8.680 6.720 ;
        RECT 0.000 5.600 8.680 6.440 ;
      LAYER met2 ;
        RECT 8.680 5.600 9.520 7.000 ;
      LAYER met2 ;
        RECT 9.520 5.600 10.080 7.000 ;
      LAYER met2 ;
        RECT 10.080 5.600 10.920 7.000 ;
      LAYER met2 ;
        RECT 10.920 5.600 11.480 7.000 ;
      LAYER met2 ;
        RECT 11.480 5.600 12.320 7.000 ;
      LAYER met2 ;
        RECT 12.320 5.600 12.880 7.000 ;
      LAYER met2 ;
        RECT 12.880 5.600 13.720 7.000 ;
      LAYER met2 ;
        RECT 13.720 5.600 14.280 7.000 ;
      LAYER met2 ;
        RECT 14.280 5.600 15.120 7.000 ;
      LAYER met2 ;
        RECT 15.120 5.600 15.680 7.000 ;
      LAYER met2 ;
        RECT 15.680 5.600 16.520 7.000 ;
      LAYER met2 ;
        RECT 16.520 5.600 17.080 7.000 ;
      LAYER met2 ;
        RECT 17.080 5.600 17.920 7.000 ;
      LAYER met2 ;
        RECT 17.920 6.720 24.920 7.000 ;
      LAYER met2 ;
        RECT 24.920 6.720 26.040 7.280 ;
      LAYER met2 ;
        RECT 17.920 6.440 25.200 6.720 ;
      LAYER met2 ;
        RECT 25.200 6.440 26.040 6.720 ;
      LAYER met2 ;
        RECT 26.040 6.440 26.880 7.280 ;
        RECT 17.920 5.600 26.880 6.440 ;
        RECT 0.000 4.480 8.960 5.600 ;
      LAYER met2 ;
        RECT 8.960 4.480 9.240 5.600 ;
      LAYER met2 ;
        RECT 0.000 4.200 8.680 4.480 ;
      LAYER met2 ;
        RECT 8.680 4.200 9.240 4.480 ;
      LAYER met2 ;
        RECT 9.240 4.200 10.360 5.600 ;
        RECT 0.000 3.920 8.400 4.200 ;
      LAYER met2 ;
        RECT 8.400 3.920 8.960 4.200 ;
      LAYER met2 ;
        RECT 8.960 3.920 10.360 4.200 ;
        RECT 0.000 3.640 8.120 3.920 ;
      LAYER met2 ;
        RECT 8.120 3.640 8.680 3.920 ;
      LAYER met2 ;
        RECT 8.680 3.640 10.360 3.920 ;
        RECT 0.000 3.360 7.840 3.640 ;
      LAYER met2 ;
        RECT 7.840 3.360 8.400 3.640 ;
      LAYER met2 ;
        RECT 8.400 3.360 10.360 3.640 ;
      LAYER met2 ;
        RECT 10.360 3.360 10.640 5.600 ;
      LAYER met2 ;
        RECT 0.000 3.080 7.560 3.360 ;
      LAYER met2 ;
        RECT 7.560 3.080 8.120 3.360 ;
      LAYER met2 ;
        RECT 8.120 3.080 10.080 3.360 ;
      LAYER met2 ;
        RECT 10.080 3.080 10.640 3.360 ;
      LAYER met2 ;
        RECT 10.640 3.080 11.760 5.600 ;
      LAYER met2 ;
        RECT 11.760 3.080 12.040 5.600 ;
      LAYER met2 ;
        RECT 0.000 2.800 7.280 3.080 ;
      LAYER met2 ;
        RECT 7.280 2.800 7.840 3.080 ;
      LAYER met2 ;
        RECT 7.840 2.800 9.520 3.080 ;
      LAYER met2 ;
        RECT 9.520 2.800 10.360 3.080 ;
      LAYER met2 ;
        RECT 10.360 2.800 11.480 3.080 ;
      LAYER met2 ;
        RECT 11.480 2.800 12.040 3.080 ;
      LAYER met2 ;
        RECT 12.040 2.800 13.160 5.600 ;
        RECT 0.000 2.520 7.000 2.800 ;
      LAYER met2 ;
        RECT 7.000 2.520 7.560 2.800 ;
      LAYER met2 ;
        RECT 7.560 2.520 9.240 2.800 ;
      LAYER met2 ;
        RECT 9.240 2.520 9.800 2.800 ;
      LAYER met2 ;
        RECT 9.800 2.520 11.200 2.800 ;
      LAYER met2 ;
        RECT 11.200 2.520 11.760 2.800 ;
      LAYER met2 ;
        RECT 11.760 2.520 13.160 2.800 ;
        RECT 0.000 2.240 6.720 2.520 ;
      LAYER met2 ;
        RECT 6.720 2.240 7.280 2.520 ;
      LAYER met2 ;
        RECT 7.280 2.240 8.960 2.520 ;
      LAYER met2 ;
        RECT 8.960 2.240 9.520 2.520 ;
      LAYER met2 ;
        RECT 9.520 2.240 10.920 2.520 ;
      LAYER met2 ;
        RECT 10.920 2.240 11.480 2.520 ;
      LAYER met2 ;
        RECT 11.480 2.240 13.160 2.520 ;
        RECT 0.000 1.960 6.440 2.240 ;
      LAYER met2 ;
        RECT 6.440 1.960 7.000 2.240 ;
      LAYER met2 ;
        RECT 7.000 1.960 8.680 2.240 ;
      LAYER met2 ;
        RECT 8.680 1.960 9.240 2.240 ;
      LAYER met2 ;
        RECT 9.240 1.960 10.920 2.240 ;
      LAYER met2 ;
        RECT 10.920 1.960 11.200 2.240 ;
      LAYER met2 ;
        RECT 11.200 1.960 13.160 2.240 ;
      LAYER met2 ;
        RECT 13.160 1.960 13.440 5.600 ;
      LAYER met2 ;
        RECT 13.440 2.800 14.560 5.600 ;
      LAYER met2 ;
        RECT 14.560 3.080 14.840 5.600 ;
      LAYER met2 ;
        RECT 14.840 3.080 15.960 5.600 ;
      LAYER met2 ;
        RECT 15.960 3.360 16.240 5.600 ;
      LAYER met2 ;
        RECT 16.240 4.200 17.360 5.600 ;
      LAYER met2 ;
        RECT 17.360 4.480 17.640 5.600 ;
      LAYER met2 ;
        RECT 17.640 4.480 26.880 5.600 ;
      LAYER met2 ;
        RECT 17.360 4.200 17.920 4.480 ;
      LAYER met2 ;
        RECT 17.920 4.200 26.880 4.480 ;
        RECT 16.240 3.920 17.640 4.200 ;
      LAYER met2 ;
        RECT 17.640 3.920 18.200 4.200 ;
      LAYER met2 ;
        RECT 18.200 3.920 26.880 4.200 ;
        RECT 16.240 3.640 17.920 3.920 ;
      LAYER met2 ;
        RECT 17.920 3.640 18.480 3.920 ;
      LAYER met2 ;
        RECT 18.480 3.640 26.880 3.920 ;
        RECT 16.240 3.360 18.200 3.640 ;
      LAYER met2 ;
        RECT 18.200 3.360 18.760 3.640 ;
      LAYER met2 ;
        RECT 18.760 3.360 26.880 3.640 ;
      LAYER met2 ;
        RECT 15.960 3.080 16.520 3.360 ;
      LAYER met2 ;
        RECT 16.520 3.080 18.480 3.360 ;
      LAYER met2 ;
        RECT 18.480 3.080 19.040 3.360 ;
      LAYER met2 ;
        RECT 19.040 3.080 26.880 3.360 ;
      LAYER met2 ;
        RECT 14.560 2.800 15.120 3.080 ;
      LAYER met2 ;
        RECT 15.120 2.800 16.240 3.080 ;
      LAYER met2 ;
        RECT 16.240 2.800 17.080 3.080 ;
      LAYER met2 ;
        RECT 17.080 2.800 18.760 3.080 ;
      LAYER met2 ;
        RECT 18.760 2.800 19.320 3.080 ;
      LAYER met2 ;
        RECT 19.320 2.800 26.880 3.080 ;
        RECT 13.440 2.520 14.840 2.800 ;
      LAYER met2 ;
        RECT 14.840 2.520 15.400 2.800 ;
      LAYER met2 ;
        RECT 15.400 2.520 16.800 2.800 ;
      LAYER met2 ;
        RECT 16.800 2.520 17.360 2.800 ;
      LAYER met2 ;
        RECT 17.360 2.520 19.040 2.800 ;
      LAYER met2 ;
        RECT 19.040 2.520 19.600 2.800 ;
      LAYER met2 ;
        RECT 19.600 2.520 26.880 2.800 ;
        RECT 13.440 2.240 15.120 2.520 ;
      LAYER met2 ;
        RECT 15.120 2.240 15.680 2.520 ;
      LAYER met2 ;
        RECT 15.680 2.240 17.080 2.520 ;
      LAYER met2 ;
        RECT 17.080 2.240 17.640 2.520 ;
      LAYER met2 ;
        RECT 17.640 2.240 19.320 2.520 ;
      LAYER met2 ;
        RECT 19.320 2.240 19.880 2.520 ;
      LAYER met2 ;
        RECT 19.880 2.240 26.880 2.520 ;
        RECT 13.440 1.960 15.400 2.240 ;
      LAYER met2 ;
        RECT 15.400 1.960 15.680 2.240 ;
      LAYER met2 ;
        RECT 15.680 1.960 17.360 2.240 ;
      LAYER met2 ;
        RECT 17.360 1.960 17.920 2.240 ;
      LAYER met2 ;
        RECT 17.920 1.960 19.600 2.240 ;
      LAYER met2 ;
        RECT 19.600 1.960 20.160 2.240 ;
      LAYER met2 ;
        RECT 20.160 1.960 26.880 2.240 ;
        RECT 0.000 1.120 6.160 1.960 ;
      LAYER met2 ;
        RECT 6.160 1.120 7.000 1.960 ;
      LAYER met2 ;
        RECT 7.000 1.120 8.400 1.960 ;
      LAYER met2 ;
        RECT 8.400 1.120 9.240 1.960 ;
      LAYER met2 ;
        RECT 9.240 1.120 10.640 1.960 ;
      LAYER met2 ;
        RECT 10.640 1.120 11.480 1.960 ;
      LAYER met2 ;
        RECT 11.480 1.120 12.880 1.960 ;
      LAYER met2 ;
        RECT 12.880 1.120 13.720 1.960 ;
      LAYER met2 ;
        RECT 13.720 1.120 15.120 1.960 ;
      LAYER met2 ;
        RECT 15.120 1.120 15.960 1.960 ;
      LAYER met2 ;
        RECT 15.960 1.120 17.360 1.960 ;
      LAYER met2 ;
        RECT 17.360 1.120 18.200 1.960 ;
      LAYER met2 ;
        RECT 18.200 1.120 19.600 1.960 ;
      LAYER met2 ;
        RECT 19.600 1.120 20.440 1.960 ;
      LAYER met2 ;
        RECT 20.440 1.120 26.880 1.960 ;
        RECT 0.000 0.000 26.880 1.120 ;
      LAYER met3 ;
        RECT 0.000 0.000 26.880 26.880 ;
      LAYER met4 ;
        RECT 0.000 0.000 26.880 26.880 ;
      LAYER met5 ;
        RECT 0.000 0.000 26.880 26.880 ;
  END
END chip_art
END LIBRARY

